Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [VersionGUID: 05dd27ca-9d75-4fba-b423-27c7f9825ef8, NumberOfSaves: 113], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
File name: 220055
Time: 2023-10-13T16:51:51
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.6.0.0 - Alternate UI 22.6.0.0

# IfcProject, 220055
LongName: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Phase: DUSP

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Text - EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.2.7; EBC_ID projektu: KVSUPS; EBC_Nadmořská výška: 389,970; EBC_Název profese: VN; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: VN; EBC_Zodpovědný projektant: Martin Frühauf; EBC_Zpracovatel části: Projekce elektro s.r.o.; EBC_Zpracovatel části adresa: II. ulice 75, 273 07 Vinařice tel.: +420 603 897 422 e-mail: mf@martinfruhauf.cz
Identifikační data - Název budovy: Budova E; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz; Projektant: Martin Frühauf, Ing. Petra Frühaufová
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; OBJEKT: ETAPA; PROFESNÍ ČÁST: D.2.7 VN; Stav projektu: DUSP; Třída LPS: 0; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.22 02:53

# IfcBuilding, Budova E
LongName: Budova E
Text - EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.2.7; EBC_ID projektu: KVSUPS; EBC_Nadmořská výška: 389,970; EBC_Název profese: VN; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: VN; EBC_Zodpovědný projektant: Martin Frühauf; EBC_Zpracovatel části: Projekce elektro s.r.o.; EBC_Zpracovatel části adresa: II. ulice 75, 273 07 Vinařice tel.: +420 603 897 422 e-mail: mf@martinfruhauf.cz
Identifikační data - Název budovy: Budova E; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz; Projektant: Martin Frühauf, Ing. Petra Frühaufová
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; OBJEKT: ETAPA; PROFESNÍ ČÁST: D.2.7 VN; Stav projektu: DUSP; Třída LPS: 0; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.22 02:53

# IfcBuildingStorey: Podlaží:Pomocné (3)
In: Budova E
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes
Jiné - Id typu: 1520; Kategorie: Podlaží; Rodina: Podlaží; Rodina a typ: Podlaží: Pomocné; Typ: Pomocné
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Barva: 0; Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: Tečkovaná
Identifikační data(Type) - Název typu: Pomocné
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží
Name | LongName = Název | Elevation (mm) | Výška (mm) | UPRAVIL
-2.PP_SO-102 | -2.PP_SO-102 | -8000 | -8000 | Fruhauf.vinarice@seznam.cz 2023.06.19 10:10
-1.PP_SO-102 | -1.PP_SO-102 | -4000 | -4000 | Fruhauf.vinarice@seznam.cz 2023.06.19 10:11
1.NP_SO-101,102 | 1.NP_SO-101,102 | -2.44043e-09 | 0 | Fruhauf.vinarice@seznam.cz 2023.06.19 10:11

# IfcBuildingElementProxy: Electrical_Transformers_Schneider-Electric_Trihal-Dry-Transformer EcoDesign EU548:TRIHAL_24kV_A0Ak (TIER1 )_BIL2 (125/50 kV), Electrical_Transformers_Schneider-Electric_Trihal-Dry-Transformer EcoDesign EU548:TRIHAL_24kV_A0Ak (TIER1 )_BIL2 (125/50 kV):1167528
In: 1.NP_SO-101,102
Type - Material: RAL 9003, Default, <Unnamed>, Clearance
Type - Obecné - Max Ambiental Temperature: 40 C
Type - Elektroinstalace - Primary Voltage (V): 20000 V; Rated Impedance Voltage (%): 6
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - IP00 Clearance HV: 500 mm; IP00 Clearance LV: 300 mm; IP31 Clearance HV: 500 mm; IP31 Clearance LV: 200 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.10.14.11; Copyright ©: © Schneider Electric; Kód sestavy: TN00; Model: Trihal; Nadpis OmniClass: Power Transformers; Název typu: TRIHAL_24kV_A0Ak (TIER1 )_BIL2 (125/50 kV); Označení typu: 01; Popis: Transformer; Popis sestavy: Obecný prvek; URL: http://www.schneider-electric.com/en/product-range/977-trihal/; Výrobce: Schneider Electric
Type - Jiné - Kategorie: Elektrické vybavení; 100: Type : 100 kVA; 1000: Type : 1000 kVA; 1250: Type : 1250 kVA; 160: Type : 160 kVA; 1600: Type : 1600 kVA; 2000: Type : 2000 kVA; 250: Type : 250 kVA; 2500: Type : 2500 kVA; 315: Type : 315 kVA; 3150: Type : 3150 kVA; 400: Type : 400 kVA; 500: Type : 500 kVA; 630: Type : 630 kVA; 800: Type : 800 kVA; Clearance Material: Clearance; Conduit Connector Description: Conduit Surface Connector; IP00: Option : IP00; IP31: Option : IP31; Název rodiny: Electrical_Transformers_Schneider-Electric_Trihal-Dry-Transformer EcoDesign EU548; NO: Roller : NO; Switchboard Section Description: Switchboard Section Connector; TRIHAL_12kV_A0Ak(TIER1 )_BIL2 (75/28 KV): no; TRIHAL_12kV_A0Bk(TIER1)_BIL2 (75/28KV): no; TRIHAL_24kV_A0Ak (TIER1) _BIL1 (95/50 kV ): no; TRIHAL_24kV_A0Ak (TIER1 )_BIL2 (125/50 kV): yes; TRIHAL_24kV_A0Bk (TIER1)_BIL1(95/50 kV ): no; TRIHAL_24kV_A0Bk(TIER 1)_BIL2 (125/50 kV): no; TRIHAL_36kV_A0Ak(TIER1)_BIL1 (145/70KV): no; TRIHAL_36kV_A0Ak_(TIER1)_BIL2(170/70KV): no; TRIHAL_36kV_A0Bk(TIER1)_BIL2(170/70KV): no; YES: Roller : YES
Classification: TN00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 34.0141 m2; NetVolume: 6.51767 m3
Elektroinstalace – obvody - Klasifikace MCB: 1 A; Podružné rozvaděče: yes; Údaje k elektroinstalaci: 20000 V/3-630.0 kW-400 V/3-630.0 kW
Obecné - Acoustic power dB(A): 62; Acoustic Pressure at 1m dB(A): 49; Enclosure type: Type 1; HV Tappings (%): +/-2x2.5%; Manufacturing cycle: NO4/NCC; Max Altitude (m): 1000000 mm; Temperature Rise: -173.15 C; Total Weight: 1940 kg; Transformer Weight: 1940 kg; Type (Step-Up or Step-Down): Yes; Weight enclosure IP31: 0 kg
Elektroinstalace - Isolation Level (kV): 24000 V; Load losses at 75°C: 0 W; Losses (W) - load losses at 120°C: 7100 W; Losses (W) - no - load losses: 1100 W; Rated Frequency (Hz): 50 Hz; Rated Power: 630000 W; Secondary Voltage at No-Load: 400 V; Vector Groups: Dyn
Elektroinstalace – zatížení - Celková odhadovaná spotřeba: 0 W; Celková soudobost: 100; Fáze A zdánlivého zatížení: 0 W; Fáze A zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze A zdánlivého zatížení větveného obvodu: 0 W; Fáze B zdánlivého zatížení: 0 W; Fáze B zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze B zdánlivého zatížení větveného obvodu: 0 W; Fáze C zdánlivého zatížení: 0 W; Fáze C zdánlivého zatížení připojení přes kabelová oka: 0 W; Fáze C zdánlivého zatížení větveného obvodu: 0 W; Jiné připojené: 0 W
Text - CCI Funkční systém: K; CCI Komponenta: BAA; CCI Technický systém: HG
Vazby - Podlaží: 1.NP_SO-101,102; Contact Schneider Electric For System Configuration: no; Hostitel: Podlaží : 1.NP_SO-101,102; Odsazení od hostitele: -4000 mm; Výška od podlaží: -4000 mm
Fázování - Fáze vytvoření: Fáze 1
Materiály a povrchové úpravy - HV/LV Windings Material: Al/Al
Grafika - Disable warning: yes; Show clearance: yes; Show Electrical Symbol: yes
Stavba - Installation Type: Indoor; IP Rating: Option : IP00; Rated Power (kVA): Type : 630 kVA; Roller: Roller : YES
Kóty - Cable Tray Height: 50 mm; Cable Tray Width: 200 mm; Conduit_Diameter: 25 mm; Enclosure Height: 0 mm; Enclosure Length: 0 mm; Enclosure Width: 0 mm; Objem: 6.51767 m3; Plocha: 44.1148 m2; Roller Diameter F: 125 mm; Roller Pitch D: 670 mm; Roller Width G: 40 mm; Symbol_Horizontal Distance: 1420 mm; Symbol_Vertical Distance: 1015 mm; Transformer Height: 1770 mm; Transformer Length: 1480 mm; Transformer Width: 830 mm
Identifikační data - Kód prvku: TN00.01.0001; Označení: 0001
Jiné - Páteřní trasa: yes; D_1: 67.5 mm; D_2: 157.5 mm; Enclosure Height_ref: 2060 mm; Enclosure Length_ref: 1840 mm; Enclosure Width_ref: 1030 mm; Error: no; Error Number: 0; Error Text: NA; Has IP31 enclosure: no; Id typu: 885635; IP00 Clearance Ref: yes; IP31 Clearance Ref: no; Model Visibility: yes; Rodina: Electrical_Transformers_Schneider-Electric_Trihal-Dry-Transformer EcoDesign EU548; Rodina a typ: Electrical_Transformers_Schneider-Electric_Trihal-Dry-Transformer EcoDesign EU548: TRIHAL_24kV_A0Ak (TIER1 )_BIL2 (125/50 kV); Roller Clearance: 68 mm; Roller option: yes; Show IP00 clearance: yes; Show IP31 clearance: no; Show warning: no; Transformer Visibility: yes; Typ: TRIHAL_24kV_A0Ak (TIER1 )_BIL2 (125/50 kV); UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.20 09:35

# IfcBuildingElementProxy: MONObox_4860_1525:MONObox_4860_1525, MONObox_4860_1525:MONObox_4860_1525:1089251
In: 1.NP_SO-101,102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.80.00.00; Kód sestavy: MT00; Nadpis OmniClass: Electric Power and Lighting; Název typu: MONObox_4860_1525; Označení typu: 03; Popis: Výstup z kabelové komory pro napojení ovládání vjezdu do prostoru garáže v budově; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Elektrická tělesa; Název rodiny: MONObox_4860_1525
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 14.2957 m2; NetVolume: 3.66022 m3
Text - CCI Funkční systém: K; CCI Komponenta: UBA; CCI Technický systém: HG
Vazby - Podlaží: 1.NP_SO-101,102; Přesunout s blízkými prvky: no; Hostitel: Podlaží : 1.NP_SO-101,102; Odsazení od hostitele: -4090 mm; Výška od podlaží: -4090 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 3.66022 m3; Plocha: 7.14783 m2
Identifikační data - Kód prvku: MT00.03.0043; Komentáře: Kabelová komora; Označení: 0043
Jiné - Páteřní trasa: yes; Id typu: 1089232; Rodina: MONObox_4860_1525; Rodina a typ: MONObox_4860_1525: MONObox_4860_1525; Typ: MONObox_4860_1525; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 05:10

# IfcBuildingElementProxy: MONObox_4860_915:MONObox_4860_915, MONObox_4860_915:MONObox_4860_915:1091305
In: 1.NP_SO-101,102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.80.00.00; Kód sestavy: MT00; Nadpis OmniClass: Electric Power and Lighting; Název typu: MONObox_4860_915; Označení typu: 04; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Elektrická tělesa; Název rodiny: MONObox_4860_915
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 12.7375 m2; NetVolume: 2.38813 m3
Text - CCI Funkční systém: K; CCI Komponenta: UBA; CCI Technický systém: HG
Vazby - Podlaží: 1.NP_SO-101,102; Přesunout s blízkými prvky: no; Hostitel: Podlaží : 1.NP_SO-101,102; Odsazení od hostitele: -3175 mm; Výška od podlaží: -3175 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 2.38813 m3; Plocha: 6.36876 m2
Identifikační data - Kód prvku: MT00.04.0044; Označení: 0044
Jiné - Páteřní trasa: yes; Id typu: 1092077; Rodina: MONObox_4860_915; Rodina a typ: MONObox_4860_915: MONObox_4860_915; Typ: MONObox_4860_915; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 05:10

# IfcBuildingElementProxy: základní díl 9W-42_385-385-1118:základní díl 9W-42_385-385-1118 (39)
In: 1.NP_SO-101,102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.80.00.00; Kód sestavy: MT00; Nadpis OmniClass: Electric Power and Lighting; Název typu: základní díl 9W-42_385-385-1118; Označení typu: 01; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Elektrická tělesa; Název rodiny: základní díl 9W-42_385-385-1118
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 7.10713 m2; NetVolume: 0.310608 m3
Text - CCI Funkční systém: K; CCI Komponenta: UBA; CCI Technický systém: HG
Vazby - Hostitel: Podlaží : 1.NP_SO-101,102; Odsazení od hostitele: -5290 mm; Podlaží: 1.NP_SO-101,102; Přesunout s blízkými prvky: no; Výška od podlaží: -5290 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.310608 m3; Plocha: 3.55357 m2
Jiné - Id typu: 1084046; Páteřní trasa: yes; Rodina: základní díl 9W-42_385-385-1118; Rodina a typ: základní díl 9W-42_385-385-1118: základní díl 9W-42_385-385-1118; Typ: základní díl 9W-42_385-385-1118
Name (základní díl 9W-42_385-385-1118:základní díl 9W-42_385-385-1118:...) | Kód prvku | Označení | UPRAVIL
1084065 | MT00.01.0001 | 0001 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1085927 | MT00.01.0002 | 0002 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1085935 | MT00.01.0003 | 0003 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1087935 | MT00.01.0034 | 0034 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1088259 | MT00.01.0039 | 0039 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1088356 | MT00.01.0042 | 0042 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154832 | MT00.01.0047 | 0047 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154840 | MT00.01.0048 | 0048 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154848 | MT00.01.0049 | 0049 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154856 | MT00.01.0050 | 0050 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154880 | MT00.01.0051 | 0051 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154881 | MT00.01.0052 | 0052 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154882 | MT00.01.0053 | 0053 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154883 | MT00.01.0054 | 0054 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154884 | MT00.01.0055 | 0055 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154894 | MT00.01.0056 | 0056 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154895 | MT00.01.0057 | 0057 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154896 | MT00.01.0058 | 0058 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154897 | MT00.01.0059 | 0059 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154898 | MT00.01.0060 | 0060 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154906 | MT00.01.0061 | 0061 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154907 | MT00.01.0062 | 0062 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154908 | MT00.01.0063 | 0063 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154909 | MT00.01.0064 | 0064 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154910 | MT00.01.0065 | 0065 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154918 | MT00.01.0066 | 0066 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154919 | MT00.01.0067 | 0067 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154920 | MT00.01.0068 | 0068 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154921 | MT00.01.0069 | 0069 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154922 | MT00.01.0070 | 0070 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154930 | MT00.01.0071 | 0071 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154931 | MT00.01.0072 | 0072 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154932 | MT00.01.0073 | 0073 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154933 | MT00.01.0074 | 0074 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154934 | MT00.01.0075 | 0075 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154942 | MT00.01.0076 | 0076 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154943 | MT00.01.0077 | 0077 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154944 | MT00.01.0078 | 0078 | Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
1154945 | MT00.01.0079 | 0079 | Fruhauf.vinarice@seznam.cz 2023.06.26 05:10

# IfcBuildingElementProxy: základní díl 9W-M_385-385-356:základní díl 9W-M_385-385-356 (38)
In: 1.NP_SO-101,102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.80.00.00; Kód sestavy: MT00; Nadpis OmniClass: Electric Power and Lighting; Název typu: základní díl 9W-M_385-385-356; Označení typu: 02; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Elektrická tělesa; Název rodiny: základní díl 9W-M_385-385-356
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.31365 m2; NetVolume: 0.0833475 m3
Text - CCI Funkční systém: K; CCI Komponenta: UBA; CCI Technický systém: HG
Vazby - Podlaží: 1.NP_SO-101,102; Přesunout s blízkými prvky: no; Hostitel: Podlaží : 1.NP_SO-101,102; Odsazení od hostitele: -5290 mm; Výška od podlaží: -5290 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0833475 m3; Plocha: 1.15683 m2
Jiné - Páteřní trasa: yes; Id typu: 1086779; Rodina: základní díl 9W-M_385-385-356; Rodina a typ: základní díl 9W-M_385-385-356: základní díl 9W-M_385-385-356; Typ: základní díl 9W-M_385-385-356; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:45
Name (základní díl 9W-M_385-385-356:základní díl 9W-M_385-385-356:...) | Kód prvku | Označení
1086798 | MT00.02.0004 | 0004
1086977 | MT00.02.0005 | 0005
1087052 | MT00.02.0006 | 0006
1087106 | MT00.02.0007 | 0007
1087135 | MT00.02.0008 | 0008
1087182 | MT00.02.0009 | 0009
1087235 | MT00.02.0010 | 0010
1087243 | MT00.02.0011 | 0011
1087251 | MT00.02.0012 | 0012
1087423 | MT00.02.0013 | 0013
1087431 | MT00.02.0014 | 0014
1087439 | MT00.02.0015 | 0015
1087522 | MT00.02.0016 | 0016
1087530 | MT00.02.0017 | 0017
1087538 | MT00.02.0018 | 0018
1087546 | MT00.02.0019 | 0019
1087622 | MT00.02.0020 | 0020
1087630 | MT00.02.0021 | 0021
1087638 | MT00.02.0022 | 0022
1087646 | MT00.02.0023 | 0023
1087654 | MT00.02.0024 | 0024
1087752 | MT00.02.0025 | 0025
1087760 | MT00.02.0026 | 0026
1087770 | MT00.02.0027 | 0027
1087780 | MT00.02.0028 | 0028
1087792 | MT00.02.0029 | 0029
1087889 | MT00.02.0030 | 0030
1087899 | MT00.02.0031 | 0031
1087907 | MT00.02.0032 | 0032
1087915 | MT00.02.0033 | 0033
1087980 | MT00.02.0035 | 0035
1088167 | MT00.02.0036 | 0036
1088202 | MT00.02.0037 | 0037
1088210 | MT00.02.0038 | 0038
1088289 | MT00.02.0040 | 0040
1088324 | MT00.02.0041 | 0041
1092153 | MT00.02.0045 | 0045
1092240 | MT00.02.0046 | 0046

# IfcDistributionPort (4)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | PredefinedType | SystemType
Port_1167528_1 | CABLE | ELECTRICAL
Port_1167528_2 | CABLE | ELECTRICAL
Port_1167528_4 | CABLECARRIER | CONVEYING
Port_1167528_5 | CABLECARRIER | CONVEYING
