Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [VersionGUID: 694a1593-d872-45c5-8fe2-96c3060609eb, NumberOfSaves: 95], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
File name: 220055
Time: 2023-10-13T16:51:52
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.6.0.0 - Alternate UI 22.6.0.0

# IfcProject, 220055
LongName: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Phase: DUSP

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Text - EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.2.8; EBC_ID projektu: KVSUPS; EBC_Nadmořská výška: 389,970; EBC_Název profese: SEK; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: SEK; EBC_Zodpovědný projektant: Martin Frühauf; EBC_Zpracovatel části: Projekce elektro s.r.o.; EBC_Zpracovatel části adresa: II. ulice 75, 273 07 Vinařice tel.: +420 603 897 422 e-mail: mf@martinfruhauf.cz
Identifikační data - Název budovy: Budova E; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz; Projektant: Martin Frühauf, Ing. Petra Frühaufová
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; OBJEKT: ETAPA; PROFESNÍ ČÁST: D.2.8 SEK; Stav projektu: DUSP; Třída LPS: 0; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.22 03:51

# IfcBuilding, Budova E
LongName: Budova E
Text - EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.2.8; EBC_ID projektu: KVSUPS; EBC_Nadmořská výška: 389,970; EBC_Název profese: SEK; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: SEK; EBC_Zodpovědný projektant: Martin Frühauf; EBC_Zpracovatel části: Projekce elektro s.r.o.; EBC_Zpracovatel části adresa: II. ulice 75, 273 07 Vinařice tel.: +420 603 897 422 e-mail: mf@martinfruhauf.cz
Identifikační data - Název budovy: Budova E; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz; Projektant: Martin Frühauf, Ing. Petra Frühaufová
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; OBJEKT: ETAPA; PROFESNÍ ČÁST: D.2.8 SEK; Stav projektu: DUSP; Třída LPS: 0; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.22 03:51

# IfcBuildingStorey: Podlaží:Pomocné (3)
In: Budova E
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes
Jiné - Id typu: 1520; Kategorie: Podlaží; Rodina: Podlaží; Rodina a typ: Podlaží: Pomocné; Typ: Pomocné; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.20 01:45
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Barva: 0; Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: Tečkovaná
Identifikační data(Type) - Název typu: Pomocné
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží
Name | LongName = Název | Elevation (mm) | Výška (mm)
-2.PP_SO-101 | -2.PP_SO-101 | -8000 | -8000
-1.PP_SO-101 | -1.PP_SO-101 | -3150 | -3150
1.NP_SO-101,102 | 1.NP_SO-101,102 | -7.27687e-10 | 0

# IfcBuildingElementProxy: MONObox_4860_1525:MONObox_4860_1525, MONObox_4860_1525:MONObox_4860_1525:1098761
In: 1.NP_SO-101,102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.80.00.00; Kód sestavy: MT00; Nadpis OmniClass: Electric Power and Lighting; Název typu: MONObox_4860_1525; Označení typu: 02; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Elektrická tělesa; Název rodiny: MONObox_4860_1525
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 14.2957 m2; NetVolume: 3.66022 m3
Text - CCI Funkční systém: K; CCI Komponenta: UBA; CCI Technický systém: HG
Vazby - Podlaží: 1.NP_SO-101,102; Přesunout s blízkými prvky: no; Hostitel: Podlaží : 1.NP_SO-101,102; Odsazení od hostitele: -4090 mm; Výška od podlaží: -4090 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 3.66022 m3; Plocha: 7.14783 m2
Identifikační data - Kód prvku: MT00.02.0002; Označení: 0002
Jiné - Páteřní trasa: yes; Id typu: 1097954; Rodina: MONObox_4860_1525; Rodina a typ: MONObox_4860_1525: MONObox_4860_1525; Typ: MONObox_4860_1525; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 05:18

# IfcBuildingElementProxy: MONObox_4860_915:MONObox_4860_915, MONObox_4860_915:MONObox_4860_915:1098755
In: 1.NP_SO-101,102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.80.00.00; Kód sestavy: MT00; Nadpis OmniClass: Electric Power and Lighting; Název typu: MONObox_4860_915; Označení typu: 01; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Elektrická tělesa; Název rodiny: MONObox_4860_915
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 12.7375 m2; NetVolume: 2.38813 m3
Text - CCI Funkční systém: K; CCI Komponenta: UBA; CCI Technický systém: HG
Vazby - Hostitel: Podlaží : 1.NP_SO-101,102; Odsazení od hostitele: -3175 mm; Podlaží: 1.NP_SO-101,102; Přesunout s blízkými prvky: no; Výška od podlaží: -3175 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 2.38813 m3; Plocha: 6.36876 m2
Identifikační data - Kód prvku: MT00.01.0001; Označení: 0001
Jiné - Id typu: 1098739; Páteřní trasa: yes; Rodina: MONObox_4860_915; Rodina a typ: MONObox_4860_915: MONObox_4860_915; Typ: MONObox_4860_915; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 05:18

# IfcBuildingElementProxy: základní díl 9W-42_385-385-1118:základní díl 9W-42_385-385-1118 (39)
In: 1.NP_SO-101,102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.80.00.00; Kód sestavy: MT00; Nadpis OmniClass: Electric Power and Lighting; Název typu: základní díl 9W-42_385-385-1118; Označení typu: 03; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Elektrická tělesa; Název rodiny: základní díl 9W-42_385-385-1118
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 7.10713 m2; NetVolume: 0.310608 m3
Text - CCI Funkční systém: K; CCI Komponenta: UBA; CCI Technický systém: HG
Vazby - Podlaží: 1.NP_SO-101,102; Přesunout s blízkými prvky: no; Hostitel: Podlaží : 1.NP_SO-101,102; Odsazení od hostitele: -5290 mm; Výška od podlaží: -5290 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.310608 m3; Plocha: 3.55357 m2
Jiné - Páteřní trasa: yes; Id typu: 1096332; Rodina: základní díl 9W-42_385-385-1118; Rodina a typ: základní díl 9W-42_385-385-1118: základní díl 9W-42_385-385-1118; Typ: základní díl 9W-42_385-385-1118; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:49
Name (základní díl 9W-42_385-385-1118:základní díl 9W-42_385-385-1118:...) | Kód prvku | Označení
1098767 | MT00.03.0003 | 0003
1098833 | MT00.03.0005 | 0005
1098869 | MT00.03.0006 | 0006
1098877 | MT00.03.0007 | 0007
1098887 | MT00.03.0008 | 0008
1098895 | MT00.03.0009 | 0009
1098903 | MT00.03.0010 | 0010
1098911 | MT00.03.0011 | 0011
1098921 | MT00.03.0012 | 0012
1098933 | MT00.03.0013 | 0013
1098943 | MT00.03.0014 | 0014
1098951 | MT00.03.0015 | 0015
1098961 | MT00.03.0016 | 0016
1099018 | MT00.03.0017 | 0017
1099019 | MT00.03.0018 | 0018
1099020 | MT00.03.0019 | 0019
1099021 | MT00.03.0020 | 0020
1099022 | MT00.03.0021 | 0021
1099023 | MT00.03.0022 | 0022
1099024 | MT00.03.0023 | 0023
1099025 | MT00.03.0024 | 0024
1099026 | MT00.03.0025 | 0025
1099027 | MT00.03.0026 | 0026
1099028 | MT00.03.0027 | 0027
1099029 | MT00.03.0028 | 0028
1099030 | MT00.03.0029 | 0029
1099040 | MT00.03.0030 | 0030
1099041 | MT00.03.0031 | 0031
1099042 | MT00.03.0032 | 0032
1099043 | MT00.03.0033 | 0033
1099044 | MT00.03.0034 | 0034
1099045 | MT00.03.0035 | 0035
1099046 | MT00.03.0036 | 0036
1099047 | MT00.03.0037 | 0037
1099049 | MT00.03.0038 | 0038
1099050 | MT00.03.0039 | 0039
1099051 | MT00.03.0040 | 0040
1099052 | MT00.03.0041 | 0041
1099128 | MT00.03.0042 | 0042

# IfcBuildingElementProxy: základní díl 9W-M_385-385-356:základní díl 9W-M_385-385-356 (38)
In: 1.NP_SO-101,102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.80.00.00; Kód sestavy: MT00; Nadpis OmniClass: Electric Power and Lighting; Název typu: základní díl 9W-M_385-385-356; Označení typu: 04; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Elektrická tělesa; Název rodiny: základní díl 9W-M_385-385-356
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.31365 m2; NetVolume: 0.0833475 m3
Text - CCI Funkční systém: K; CCI Komponenta: UBA; CCI Technický systém: HG
Vazby - Podlaží: 1.NP_SO-101,102; Přesunout s blízkými prvky: no; Hostitel: Podlaží : 1.NP_SO-101,102; Odsazení od hostitele: -5290 mm; Výška od podlaží: -5290 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0833475 m3; Plocha: 1.15683 m2
Jiné - Páteřní trasa: yes; Id typu: 1097176; Rodina: základní díl 9W-M_385-385-356; Rodina a typ: základní díl 9W-M_385-385-356: základní díl 9W-M_385-385-356; Typ: základní díl 9W-M_385-385-356; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 12:49
Name (základní díl 9W-M_385-385-356:základní díl 9W-M_385-385-356:...) | Kód prvku | Označení
1098773 | MT00.04.0004 | 0004
1099144 | MT00.04.0043 | 0043
1099152 | MT00.04.0044 | 0044
1099160 | MT00.04.0045 | 0045
1099172 | MT00.04.0046 | 0046
1099243 | MT00.04.0047 | 0047
1099262 | MT00.04.0048 | 0048
1099272 | MT00.04.0049 | 0049
1099428 | MT00.04.0050 | 0050
1099465 | MT00.04.0051 | 0051
1099473 | MT00.04.0052 | 0052
1099508 | MT00.04.0053 | 0053
1099516 | MT00.04.0054 | 0054
1099528 | MT00.04.0055 | 0055
1099538 | MT00.04.0056 | 0056
1099666 | MT00.04.0057 | 0057
1099728 | MT00.04.0058 | 0058
1099736 | MT00.04.0059 | 0059
1099744 | MT00.04.0060 | 0060
1099754 | MT00.04.0061 | 0061
1099764 | MT00.04.0062 | 0062
1099772 | MT00.04.0063 | 0063
1099780 | MT00.04.0064 | 0064
1099790 | MT00.04.0065 | 0065
1099798 | MT00.04.0066 | 0066
1100002 | MT00.04.0067 | 0067
1100012 | MT00.04.0068 | 0068
1100020 | MT00.04.0069 | 0069
1100030 | MT00.04.0070 | 0070
1100040 | MT00.04.0071 | 0071
1100048 | MT00.04.0072 | 0072
1100058 | MT00.04.0073 | 0073
1100066 | MT00.04.0074 | 0074
1100076 | MT00.04.0075 | 0075
1100086 | MT00.04.0076 | 0076
1100094 | MT00.04.0077 | 0077
1100104 | MT00.04.0078 | 0078
1100357 | MT00.04.0079 | 0079
