Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [VersionGUID: 953a0762-b8a1-40d8-b33d-b5ae3203def6, NumberOfSaves: 141], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
File name: 220055
Time: 2023-10-13T16:47:08
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.6.0.0 - Alternate UI 22.6.0.0

# IfcProject, 220055
LongName: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Phase: DUSP

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Identifikační data - EBC_ID projektu: KVSUPS; EBC_ID stavebního objektu: "SO-XXX"; EBC_Zodpovědný projektant: Ing. Michal Pávek; EBC_Zpracovatel části: Energy Benefit Centre a.s.; EBC_Zpracovatel části adresa: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz internet: www.energy-benefit.cz; Název budovy: "NÁZEV STAVEBNÍHO OBJEKTU"; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz internet: www.energy-benefit.cz; Projektant: Ing. Michal Pávek, Ing. Ondřej Mládek
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.2.5; EBC_Nadmořská výška: 389,970; EBC_Název profese: PŘÍPOJKA HORKOVODU; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: CZT; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Stav projektu: DUSP

# IfcBuilding, "NÁZEV STAVEBNÍHO OBJEKTU"
LongName: "NÁZEV STAVEBNÍHO OBJEKTU"
Identifikační data - EBC_ID projektu: KVSUPS; EBC_ID stavebního objektu: "SO-XXX"; EBC_Zodpovědný projektant: Ing. Michal Pávek; EBC_Zpracovatel části: Energy Benefit Centre a.s.; EBC_Zpracovatel části adresa: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz internet: www.energy-benefit.cz; Název budovy: "NÁZEV STAVEBNÍHO OBJEKTU"; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz internet: www.energy-benefit.cz; Projektant: Ing. Michal Pávek, Ing. Ondřej Mládek
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.2.5; EBC_Nadmořská výška: 389,970; EBC_Název profese: PŘÍPOJKA HORKOVODU; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: CZT; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Stav projektu: DUSP

# IfcBuildingStorey: Podlaží:Podlaží, -1.PP_SO-102
In: "NÁZEV STAVEBNÍHO OBJEKTU"
LongName: -1.PP_SO-102; Elevation: -4000 mm
Vazby - Podlaží nad: 1.NP_SO-101,102; Výška: -4000 mm
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Název: -1.PP_SO-102; Podlaží budovy: yes
Jiné - Id typu: 305; Kategorie: Podlaží; Rodina: Podlaží; Rodina a typ: Podlaží: Podlaží; Typ: Podlaží
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Barva: 0; Symbol: EBC_Záhlaví podlaží : Běžné; Symbol na konci 1 – výchozí: yes; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: EB_Tečkovaná 1/50
Identifikační data(Type) - Název typu: Podlaží
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží

# IfcBuildingStorey: Podlaží:Podlaží ±0,000, 1.NP_SO-101,102
In: "NÁZEV STAVEBNÍHO OBJEKTU"
LongName: 1.NP_SO-101,102; Elevation: 7.58007e-12 mm
Vazby - Výška: 0 mm
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes; Název: 1.NP_SO-101,102
Jiné - Kategorie: Podlaží; Rodina: Podlaží; Id typu: 237447; Rodina a typ: Podlaží: Podlaží ±0,000; Typ: Podlaží ±0,000
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: EB_Tečkovaná 1/50; Barva: 16711935; Symbol: EBC_Záhlaví podlaží : +-0,000; Symbol na konci 1 – výchozí: no
Identifikační data(Type) - Název typu: Podlaží ±0,000
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží

# IfcCovering: Izolace trubky:Tepelná (43)
In: -1.PP_SO-102
PredefinedType: INSULATION; Classification: IZ01 Uniformat (Uniformat)
Text - CCI Funkční systém: H; CCI Komponenta: RQA; CCI Technický systém: HD
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Tloušťka izolace: 100 mm
Jiné - Id typu: 9105621; Kategorie: Izolace trubky; Rodina: Izolace trubky; Rodina a typ: Izolace trubky: Tepelná; Typ: Tepelná
Požární ochrana(Type) - Požární odolnost: A1
Identifikační data(Type) - ID kategorie: IZT; Kód sestavy: IZ01; Název typu: Tepelná; Označení typu: 01; Popis: TEPELNÁ IZOLACE; Popis sestavy: Tepelná
Jiné(Type) - Kategorie: Izolace trubky; MJ: m; Název rodiny: Izolace trubky
Name (Izolace trubky:Tepelná:...) | Material | Typ systému | Klasifikace systému | Název systému | Objem (m3) | Plocha (m2) | Délka (mm) | Velikost potrubí | Kód prvku | Označení
12765830 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 2.30584 | 23.0584 | 23830.3 | ø100 | IZ01.01.0001 | 0001
12765831 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 1.7226 | 17.226 | 17802.6 | ø100 | IZ01.01.0002 | 0002
12765832 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.302601 | 3.02601 | 3127.3 | ø100 | IZ01.01.0003 | 0003
12765834 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  |  | ø100-ø100 | IZ01.01.0004 | 0004
12765835 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  |  | ø100-ø100 | IZ01.01.0005 | 0005
12765847 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 0.268963 | 2.68963 | 2779.66 | ø100 | IZ01.01.0006 | 0006
12765848 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 0.310017 | 3.10017 | 3203.94 | ø100 | IZ01.01.0007 | 0007
12765849 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 1.7038 | 17.038 | 17608.3 | ø100 | IZ01.01.0008 | 0008
12765850 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 2.34369 | 23.4369 | 24221.4 | ø100 | IZ01.01.0009 | 0009
12765851 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 |  |  |  | ø100-ø100 | IZ01.01.0010 | 0010
12765854 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 0.293924 | 2.93924 | 3037.62 | ø100 | IZ01.01.0011 | 0011
12768782 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.243069 | 2.43069 | 2512.05 | ø100 | IZ01.01.0012 | 0012
12769542 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.0261169 | 0.261169 | 269.911 | ø100 | IZ01.01.0013 | 0013
12769546 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 0.0269269 | 0.269269 | 278.283 | ø100 | IZ01.01.0014 | 0014
12770152 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 |  |  |  | ø100-ø100 | IZ01.01.0015 | 0015
12771049 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.26066 | 2.6066 | 2693.86 | ø100 | IZ01.01.0016 | 0016
12771443 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 |  |  |  | ø100-ø100 | IZ01.01.0017 | 0017
12771480 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  |  | ø100-ø100 | IZ01.01.0018 | 0018
12771485 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  |  | ø100-ø100 | IZ01.01.0019 | 0019
12771641 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.0322298 | 0.322298 | 371.57 | ø65 | IZ01.01.0020 | 0020
12771919 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 0.0331169 | 0.331169 | 381.798 | ø65 | IZ01.01.0021 | 0021
12771945 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 |  |  |  | ø100-ø100 | IZ01.01.0022 | 0022
12773333 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  |  | ø100-ø100 | IZ01.01.0023 | 0023
12773334 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  |  | ø100-ø100 | IZ01.01.0024 | 0024
12773339 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  |  | ø100-ø100 | IZ01.01.0025 | 0025
12773399 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 |  |  |  | ø100-ø100 | IZ01.01.0026 | 0026
12773404 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 |  |  |  | ø100-ø100 | IZ01.01.0027 | 0027
12773850 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 0.301142 | 3.01142 | 3112.23 | ø100 | IZ01.01.0028 | 0028 | Qto_CoveringBaseQuantities - GrossArea: 0.0744948 m2
12773869 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 |  |  |  | ø65-ø65 | IZ01.01.0029 | 0029
12773873 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 4.42756 | 44.2756 | 45757.7 | ø100 | IZ01.01.0030 | 0030
12773878 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 |  |  |  | ø100-ø100-ø100 | IZ01.01.0031 | 0031
12773884 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 |  |  |  | ø100-ø65 | IZ01.01.0032 | 0032
12773901 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.25771 | 2.5771 | 2663.37 | ø100 | IZ01.01.0033 | 0033 | Qto_CoveringBaseQuantities - GrossArea: 0.0744948 m2
12773917 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  |  | ø65-ø65 | IZ01.01.0034 | 0034
12773921 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 4.4945 | 44.945 | 46449.5 | ø100 | IZ01.01.0035 | 0035
12773926 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  |  | ø100-ø100-ø100 | IZ01.01.0036 | 0036
12773932 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  |  | ø100-ø65 | IZ01.01.0037 | 0037
12786565 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.832739 | 8.32739 | 9600.47 | ø65 | IZ01.01.0038 | 0038
12786568 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 4.26172 | 42.6172 | 49132.5 | ø65 | IZ01.01.0039 | 0039
12786574 | 255-128-128 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  |  | ø65-ø65 | IZ01.01.0040 | 0040
12786605 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 0.791103 | 7.91103 | 9120.46 | ø65 | IZ01.01.0041 | 0041
12786608 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 4.19612 | 41.9612 | 48376.2 | ø65 | IZ01.01.0042 | 0042
12786613 | 0-128-255 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 |  |  |  | ø65-ø65 | IZ01.01.0043 | 0043

# IfcDistributionPort (88)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE; SystemType: HEATING
Name | Group
Port_12764572_0 | HT_PRIMÁR_přívodní 1
Port_12764572_1 | HT_PRIMÁR_přívodní 1
Port_12764775_1 | HT_PRIMÁR_přívodní 1
Port_12764605_0 | HT_PRIMÁR_přívodní 1
Port_12764775_2 | HT_PRIMÁR_přívodní 1
Port_12764605_1 | HT_PRIMÁR_přívodní 1
Port_12764781_2 | HT_PRIMÁR_přívodní 1
Port_12764630_0 | HT_PRIMÁR_přívodní 1
Port_12764781_1 | HT_PRIMÁR_přívodní 1
Port_12764630_1 | HT_PRIMÁR_přívodní 1
Port_12773328_1 | HT_PRIMÁR_přívodní 1
Port_12765350_0 | HT_PRIMÁR_vratné 1
Port_12771438_2 | HT_PRIMÁR_vratné 1
Port_12765350_1 | HT_PRIMÁR_vratné 1
Port_12771943_2 | HT_PRIMÁR_vratné 1
Port_12765384_0 | HT_PRIMÁR_vratné 1
Port_12770150_1 | HT_PRIMÁR_vratné 1
Port_12765384_1 | HT_PRIMÁR_vratné 1
Port_12773397_1 | HT_PRIMÁR_vratné 1
Port_12765403_0 | HT_PRIMÁR_vratné 1
Port_12765516_2 | HT_PRIMÁR_vratné 1
Port_12765403_1 | HT_PRIMÁR_vratné 1
Port_12770150_2 | HT_PRIMÁR_vratné 1
Port_12765419_0 | HT_PRIMÁR_vratné 1
Port_12765516_1 | HT_PRIMÁR_vratné 1
Port_12765419_1 | HT_PRIMÁR_vratné 1
Port_12767738_0 | HT_PRIMÁR_vratné 1
Port_12773397_2 | HT_PRIMÁR_vratné 1
Port_12767738_1 | HT_PRIMÁR_vratné 1
Port_12773400_2 | HT_PRIMÁR_vratné 1
Port_12768480_0 | HT_PRIMÁR_přívodní 1
Port_12773335_1 | HT_PRIMÁR_přívodní 1
Port_12768480_1 | HT_PRIMÁR_přívodní 1
Port_12771476_1 | HT_PRIMÁR_přívodní 1
Port_12768766_0 | HT_PRIMÁR_přívodní 1
Port_12773330_2 | HT_PRIMÁR_přívodní 1
Port_12768766_1 | HT_PRIMÁR_přívodní 1
Port_12773335_2 | HT_PRIMÁR_přívodní 1
Port_12768875_0 | HT_PRIMÁR_vratné 1
Port_12771438_1 | HT_PRIMÁR_vratné 1
Port_12768875_1 | HT_PRIMÁR_vratné 1
Port_12773400_1 | HT_PRIMÁR_vratné 1
Port_12771047_0 | HT_PRIMÁR_přívodní 1
Port_12771476_2 | HT_PRIMÁR_přívodní 1
Port_12771047_1 | HT_PRIMÁR_přívodní 1
Port_12771481_2 | HT_PRIMÁR_přívodní 1
Port_12771050_0 | HT_PRIMÁR_přívodní 1
Port_12773918_2 | HT_PRIMÁR_přívodní 1
Port_12771050_1 | HT_PRIMÁR_přívodní 1
Port_12771481_1 | HT_PRIMÁR_přívodní 1
Port_12771604_0 | HT_PRIMÁR_přívodní 1
Port_12773913_2 | HT_PRIMÁR_přívodní 1
Port_12771604_1 | HT_PRIMÁR_přívodní 1
Port_12773929_2 | HT_PRIMÁR_přívodní 1
Port_12771793_0 | HT_PRIMÁR_vratné 1
Port_12773870_2 | HT_PRIMÁR_vratné 1
Port_12771793_1 | HT_PRIMÁR_vratné 1
Port_12771943_1 | HT_PRIMÁR_vratné 1
Port_12771889_0 | HT_PRIMÁR_vratné 1
Port_12773865_2 | HT_PRIMÁR_vratné 1
Port_12771889_1 | HT_PRIMÁR_vratné 1
Port_12773881_2 | HT_PRIMÁR_vratné 1
Port_12773328_2 | HT_PRIMÁR_přívodní 1
Port_12773330_1 | HT_PRIMÁR_přívodní 1
Port_12773865_1 | HT_PRIMÁR_vratné 1
Port_12786606_0 | HT_PRIMÁR_vratné 1
Port_12773870_1 | HT_PRIMÁR_vratné 1
Port_12773871_1 | HT_PRIMÁR_vratné 1
Port_12773870_3 | HT_PRIMÁR_vratné 1
Port_12773881_1 | HT_PRIMÁR_vratné 1
Port_12773871_0 | HT_PRIMÁR_vratné 1
Port_12773913_1 | HT_PRIMÁR_přívodní 1
Port_12786566_0 | HT_PRIMÁR_přívodní 1
Port_12773918_1 | HT_PRIMÁR_přívodní 1
Port_12773919_1 | HT_PRIMÁR_přívodní 1
Port_12773918_3 | HT_PRIMÁR_přívodní 1
Port_12773929_1 | HT_PRIMÁR_přívodní 1
Port_12773919_0 | HT_PRIMÁR_přívodní 1
Port_12786563_0 | HT_PRIMÁR_přívodní 1
Port_12786569_1 | HT_PRIMÁR_přívodní 1
Port_12786563_1 | HT_PRIMÁR_přívodní 1
Port_12786566_1 | HT_PRIMÁR_přívodní 1
Port_12786569_2 | HT_PRIMÁR_přívodní 1
Port_12786603_0 | HT_PRIMÁR_vratné 1
Port_12786609_1 | HT_PRIMÁR_vratné 1
Port_12786603_1 | HT_PRIMÁR_vratné 1
Port_12786606_1 | HT_PRIMÁR_vratné 1
Port_12786609_2 | HT_PRIMÁR_vratné 1

# IfcDistributionSystem: HT_PRIMÁR_přívodní, HT_PRIMÁR_přívodní 1
PredefinedType: HEATING

# IfcDistributionSystem: HT_PRIMÁR_vratné, HT_PRIMÁR_vratné 1
PredefinedType: HEATING

# IfcPipeFitting: M_Koleno, obecné:Standardní (16)
In: 1.NP_SO-101,102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: K; Kód sestavy: TT01; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 01; Popis: Koleno; Popis sestavy: Koleno
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Koleno, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 100 mm; Typ izolace: Tepelná
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HD
Vazby - Podlaží: 1.NP_SO-101,102
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Jiné - Páteřní trasa: yes; Id typu: 3326550; Rodina: M_Koleno, obecné; Rodina a typ: M_Koleno, obecné: Standardní; Typ: Standardní
Name (M_Koleno, obecné:Standardní:...) | Celková velikost | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Střední poloměr (mm) | Vnější poloměr tvarovky (mm)
12764775 | ø300 mm-ø300 mm | -2045.33 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 50 | 100 | 0.00079579 | 58.7738 | 90.0354 | ø100-ø100 | 41.9359 | 104.775 | TT01.01.0001 | 0001 | 58.7375 | 52.3875
12764781 | ø300 mm-ø300 mm | -2045.33 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 50 | 100 | 0.000799444 | 59.1995 | 90.4489 | ø100-ø100 | 42.2396 | 104.775 | TT01.01.0002 | 0002 | 58.7375 | 52.3875
12765516 | ø300 mm-ø300 mm | -2045.29 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 50 | 100 | 0.000796403 | 58.845 | 90.1048 | ø100-ø100 | 41.9867 | 104.775 | TT01.01.0003 | 0003 | 58.7375 | 52.3875
12770150 | ø300 mm-ø300 mm | -2045.29 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 50 | 100 | 0.000770023 | 55.8571 | 87.1203 | ø100-ø100 | 39.8548 | 104.775 | TT01.01.0004 | 0004 | 58.7375 | 52.3875
12771438 | ø300 mm-ø300 mm | -2299.95 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 50 | 100 | 0.000786438 | 57.6984 | 88.9773 | ø100-ø100 | 41.1686 | 104.775 | TT01.01.0005 | 0005 | 58.7375 | 52.3875
12771476 | ø300 mm-ø300 mm | -2300.08 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 50 | 100 | 0.000786492 | 57.7046 | 88.9835 | ø100-ø100 | 41.173 | 104.775 | TT01.01.0006 | 0006 | 58.7375 | 52.3875
12771481 | ø300 mm-ø300 mm | -2299.59 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 50 | 100 | 0.000777902 | 56.7337 | 88.0116 | ø100-ø100 | 40.4802 | 104.775 | TT01.01.0007 | 0007 | 58.7375 | 52.3875
12771943 | ø300 mm-ø300 mm | -2299.88 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 50 | 100 | 0.000777902 | 56.7337 | 88.0116 | ø100-ø100 | 40.4802 | 104.775 | TT01.01.0008 | 0008 | 58.7375 | 52.3875
12773328 | ø300 mm-ø300 mm | -2045.33 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 50 | 100 | 0.000777811 | 56.7235 | 88.0014 | ø100-ø100 | 40.473 | 104.775 | TT01.01.0009 | 0009 | 58.7375 | 52.3875
12773335 | ø300 mm-ø300 mm | -2051.35 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 50 | 100 | 0.000397899 | 24.3411 | 45.0187 | ø100-ø100 | 17.3677 | 104.775 | TT01.01.0011 | 0011 | 58.7375 | 52.3875
12773397 | ø300 mm-ø300 mm | -2045.29 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 50 | 100 | 0.000768877 | 55.7307 | 86.9906 | ø100-ø100 | 39.7646 | 104.775 | TT01.01.0012 | 0012 | 58.7375 | 52.3875
12773400 | ø300 mm-ø300 mm | -2045.29 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 50 | 100 | 0.000397518 | 24.3153 | 44.9757 | ø100-ø100 | 17.3493 | 104.775 | TT01.01.0013 | 0013 | 58.7375 | 52.3875
12773865 | ø265 mm-ø265 mm | -2869.99 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 32.5 | 65 | 0.000215892 | 39.1846 | 89.2694 | ø65-ø65 | 26.3321 | 66.675 | TT01.01.0014 | 0014 | 39.6875 | 33.3375
12773913 | ø265 mm-ø265 mm | -2860.35 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 32.5 | 65 | 0.000215891 | 39.1842 | 89.2688 | ø65-ø65 | 26.3318 | 66.675 | TT01.01.0017 | 0017 | 39.6875 | 33.3375
12786569 | ø265 mm-ø265 mm | -3488.33 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 32.5 | 65 | 0.00021765 | 39.685 | 89.9963 | ø65-ø65 | 26.6683 | 66.675 | TT01.01.0020 | 0020 | 39.6875 | 33.3375
12786609 | ø265 mm-ø265 mm | -3487.81 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | 32.5 | 65 | 0.00021765 | 39.685 | 89.9963 | ø65-ø65 | 26.6683 | 66.675 | TT01.01.0021 | 0021 | 39.6875 | 33.3375

# IfcPipeFitting: M_Přechod, obecný:Standardní, M_Přechod, obecný:Standardní:12773881
In: 1.NP_SO-101,102
Type - Material: 0-128-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT03; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 02; Popis: Redukce; Popis sestavy: Redukce
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT03 Uniformat (Uniformat); Group: HT_PRIMÁR_vratné 1
Izolace - Celková velikost: ø300 mm-ø265 mm; Tloušťka izolace: 100 mm; Typ izolace: Tepelná
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HD
Vazby - Podlaží: 1.NP_SO-101,102; Výška od podlaží: -2422.82 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: HT_PRIMÁR_vratné; Klasifikace systému: Zpětné vedení teplé vody; Název systému: HT_PRIMÁR_vratné 1
Grafika - Použít měřítko poznámky: no
Kóty - Délka: 26.1938 mm; Jmenovitý poloměr 1: 50 mm; Jmenovitý poloměr 2: 32.5 mm; Jmenovitý průměr 1: 100 mm; Jmenovitý průměr 2: 65 mm; Maximální velikost: 100 mm; Minimální velikost: 65 mm; Objem: 0.000153591 m3; Odskok – šířka: 49.5934; Odskok – výška: 21.2899; Plocha: 0.0126582 m2; Velikost: ø100-ø65; Velikost značky 1: 41.91 mm; Velikost značky 2: 26.67 mm; Vnější průměr tvarovky 1: 104.775 mm; Vnější průměr tvarovky 2: 66.675 mm
Identifikační data - Kód prvku: TT03.02.0016; Označení: 0016
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Viditelnost 3: no; DN tvarovky 1 (sdílený): 100 mm; DN tvarovky 2 (sdílený): 65 mm; Max. vnější průměr tvarovky 12: 104.775 mm; Šířkové odsazení: 3047.59 mm; Viditelnost 1: no; Viditelnost 2: yes; Vnější poloměr tvarovky 2: 33.3375 mm; Vnější proloměr tvarovky 1: 52.3875 mm; Výškové odsazení: 3019.29 mm

# IfcPipeFitting: M_Přechod, obecný:Standardní (2)
In: 1.NP_SO-101,102
Type - Material: 255-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT03; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 02; Popis: Redukce; Popis sestavy: Redukce
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT03 Uniformat (Uniformat); Group: HT_PRIMÁR_přívodní 1
Izolace - Tloušťka izolace: 100 mm; Typ izolace: Tepelná
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HD
Vazby - Podlaží: 1.NP_SO-101,102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: HT_PRIMÁR_přívodní; Klasifikace systému: Přívod teplé vody; Název systému: HT_PRIMÁR_přívodní 1
Grafika - Použít měřítko poznámky: no
Kóty - Délka: 26.1938 mm; Jmenovitý poloměr 1: 50 mm; Jmenovitý průměr 1: 100 mm; Maximální velikost: 100 mm; Velikost značky 1: 41.91 mm; Vnější průměr tvarovky 1: 104.775 mm
Jiné - Páteřní trasa: yes; Typ: Standardní; DN tvarovky 1 (sdílený): 100 mm; Id typu: 3336402; Max. vnější průměr tvarovky 12: 104.775 mm; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm; Viditelnost 3: no; Vnější proloměr tvarovky 1: 52.3875 mm
Name (M_Přechod, obecný:Standardní:...) | Celková velikost | Výška od podlaží (mm) | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 2 (mm) = Minimální velikost (mm) = DN tvarovky 2 (sdílený) (mm) | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 2 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Viditelnost 1 | Viditelnost 2 | Vnější poloměr tvarovky 2 (mm) | Výškové odsazení (mm)
12773330 | ø300 mm-ø300 mm | -2045.33 | 50 | 100 | 0.00022576 | 50 | 43.9844 | 0.0159175 | ø100-ø100 | 41.91 | 104.775 | TT03.02.0010 | 0010 | yes | no | 52.3875 | 3041.98
12773929 | ø300 mm-ø265 mm | -2423.4 | 32.5 | 65 | 0.000153591 | 49.9999 | 49.9956 | 0.0121568 | ø100-ø65 | 26.67 | 66.675 | TT03.02.0019 | 0019 | no | yes | 33.3375 | 3048

# IfcPipeFitting: M_Spoj T, obecný:Standardní, M_Spoj T, obecný:Standardní:12773870
In: 1.NP_SO-101,102
Type - Material: 0-128-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT02; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: T kus; Popis sestavy: Odbočka
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT02 Uniformat (Uniformat); Group: HT_PRIMÁR_vratné 1
Izolace - Celková velikost: ø300 mm-ø300 mm-ø300 mm; Tloušťka izolace: 100 mm; Typ izolace: Tepelná
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HD
Vazby - Podlaží: 1.NP_SO-101,102; Výška od podlaží: -2357.73 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: HT_PRIMÁR_vratné; Klasifikace systému: Zpětné vedení teplé vody; Název systému: HT_PRIMÁR_vratné 1
Grafika - Použít měřítko poznámky: no
Kóty - Jmenovitý poloměr: 50 mm; Jmenovitý průměr: 100 mm; Maximální velikost: 100 mm; Minimální velikost: 100 mm; Objem: 0.00130008 m3; Od středu ke konci: 65.0875 mm; Úhel: 90.0739 deg; Velikost: ø100-ø100-ø100; Velikost značky: 41.91 mm; Vnější průměr tvarovky: 104.775 mm
Identifikační data - Kód prvku: TT02.03.0015; Označení: 0015
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní; Štítek, od středu ke konci: 65.0875 mm; Úhel 1: 89.9261 deg; Úhel tvarovky 1 (sdílený): 89.9261 deg; Vnější poloměr tvarovky: 52.3875 mm

# IfcPipeFitting: M_Spoj T, obecný:Standardní, M_Spoj T, obecný:Standardní:12773918
In: 1.NP_SO-101,102
Type - Material: 255-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT02; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: T kus; Popis sestavy: Odbočka
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT02 Uniformat (Uniformat); Group: HT_PRIMÁR_přívodní 1
Izolace - Celková velikost: ø300 mm-ø300 mm-ø300 mm; Tloušťka izolace: 100 mm; Typ izolace: Tepelná
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HD
Vazby - Podlaží: 1.NP_SO-101,102; Výška od podlaží: -2358.31 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: HT_PRIMÁR_přívodní; Klasifikace systému: Přívod teplé vody; Název systému: HT_PRIMÁR_přívodní 1
Grafika - Použít měřítko poznámky: no
Kóty - Jmenovitý poloměr: 50 mm; Jmenovitý průměr: 100 mm; Maximální velikost: 100 mm; Minimální velikost: 100 mm; Objem: 0.00130008 m3; Od středu ke konci: 65.0875 mm; Úhel: 90.075 deg; Velikost: ø100-ø100-ø100; Velikost značky: 41.91 mm; Vnější průměr tvarovky: 104.775 mm
Identifikační data - Kód prvku: TT02.03.0018; Označení: 0018
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní; Štítek, od středu ke konci: 65.0875 mm; Úhel 1: 89.925 deg; Úhel tvarovky 1 (sdílený): 89.925 deg; Vnější poloměr tvarovky: 52.3875 mm

# IfcPipeSegment: Typy trubek:Ocel_černá (22)
In: 1.NP_SO-101,102
Type - Material: 255-128-128
Type - Požární ochrana - Požární odolnost: A1
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR02; Název typu: Ocel_černá; Označení typu: 01; Popis: OC; Popis sestavy: Ocel
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR02 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 100 mm; Typ izolace: Tepelná
Mechanické – tok - Doplňkový průtok: 0 m3/s; Průtok: 0 m3/s; Reynoldsovo číslo: 0; Rychlost: 0 m/s; Stav průtoku: Laminární; Tlaková ztráta: 0 Pa; Třecí faktor: 0; Tření: 0
Text - CCI Funkční systém: H; CCI Komponenta: WPA; CCI Technický systém: HD
Vazby - Horizontální zarovnání: Na střed; Referenční podlaží: 1.NP_SO-101,102; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Drsnost: 0.1 mm; Materiál: Kov, ocel; Popis úseku: FE; Typ přípoje: Obecné; Úsek potrubí: Kov, ocel - ČERNÁ SVAŘOVANÁ; Výkaz/typ: ČERNÁ SVAŘOVANÁ
Jiné - Id typu: 12487561; Páteřní trasa: yes; Rodina: Typy trubek; Rodina a typ: Typy trubek: Ocel_černá; Typ: Ocel_černá
Name (Typy trubek:Ocel_černá:...) | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Relativní drsnost | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Sklon | Spodní výška (mm) | Klasifikace systému | Název systému = Group | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Typ systému | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení
12764572 | 23830.3 | 0.00915951 | 8.08543 | ø300 mm | 0.001 | -1991.33 | -2045.33 | -2045.33 | 0 | -2099.33 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | -2095.33 | 7.48651 | 100 | 12 | HT_PRIMÁR_přívodní | ø100 | 108 | 100 | TR02.01.0001 | 0001
12764605 | 17802.6 | 0.00915951 | 6.04028 | ø300 mm | 0.001 | -1991.33 | -2045.33 | -2045.33 | 0 | -2099.33 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | -2095.33 | 5.59286 | 100 | 12 | HT_PRIMÁR_přívodní | ø100 | 108 | 100 | TR02.01.0002 | 0002
12764630 | 3127.3 | 0.00915951 | 1.06107 | ø300 mm | 0.001 | -1991.33 | -2045.33 | -2045.33 | 0 | -2099.33 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | -2095.33 | 0.982471 | 100 | 12 | HT_PRIMÁR_přívodní | ø100 | 108 | 100 | TR02.01.0003 | 0003
12765350 | 2779.66 | 0.00915951 | 0.943116 | ø300 mm | 0.001 | -2245.88 | -2299.88 | -2299.95 | 0.00252204 | -2353.95 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | -2349.95 | 0.873256 | 100 | 5 | HT_PRIMÁR_vratné | ø100 | 108 | 100 | TR02.01.0004 | 0004
12765384 | 3203.94 | 0.00915951 | 1.08707 | ø300 mm | 0.001 | -1991.29 | -2045.29 | -2045.29 | 0 | -2099.29 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | -2095.29 | 1.00655 | 100 | 5 | HT_PRIMÁR_vratné | ø100 | 108 | 100 | TR02.01.0005 | 0005
12765403 | 17608.3 | 0.00915951 | 5.97436 | ø300 mm | 0.001 | -1991.29 | -2045.29 | -2045.29 | 0 | -2099.29 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | -2095.29 | 5.53182 | 100 | 5 | HT_PRIMÁR_vratné | ø100 | 108 | 100 | TR02.01.0006 | 0006
12765419 | 24221.4 | 0.00915951 | 8.21812 | ø300 mm | 0.001 | -1991.29 | -2045.29 | -2045.29 | 0 | -2099.29 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | -2095.29 | 7.60937 | 100 | 5 | HT_PRIMÁR_vratné | ø100 | 108 | 100 | TR02.01.0007 | 0007
12767738 | 3037.62 | 0.00915951 | 1.03064 | ø300 mm | 0.001 | -1991.29 | -2045.29 | -2045.29 | 0 | -2099.29 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | -2095.29 | 0.954298 | 100 | 5 | HT_PRIMÁR_vratné | ø100 | 108 | 100 | TR02.01.0008 | 0008
12768480 | 269.911 | 0.00915951 | 0.0915786 | ø300 mm | 0.001 | -2030.35 | -2259.3 | -2068.55 | 99.8833 | -2297.5 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | -2294.67 | 0.084795 | 100 | 18 | HT_PRIMÁR_přívodní | ø100 | 108 | 100 | TR02.01.0009 | 0009
12768766 | 2512.05 | 0.00915951 | 0.852318 | ø300 mm | 0.001 | -1997.35 | -2051.35 | -2051.35 | 0 | -2105.35 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | -2101.35 | 0.789183 | 100 | 18 | HT_PRIMÁR_přívodní | ø100 | 108 | 100 | TR02.01.0010 | 0010
12768875 | 278.283 | 0.00915951 | 0.0944191 | ø300 mm | 0.001 | -2024.28 | -2062.48 | -2259.17 | 99.9151 | -2297.37 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | -2294.54 | 0.0874251 | 100 | 5 | HT_PRIMÁR_vratné | ø100 | 108 | 100 | TR02.01.0011 | 0011
12771047 | 2693.86 | 0.00915951 | 0.914004 | ø300 mm | 0.001 | -2245.6 | -2299.6 | -2300.07 | 0.0171592 | -2354.07 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | -2350.07 | 0.8463 | 100 | 18 | HT_PRIMÁR_přívodní | ø100 | 108 | 100 | TR02.01.0012 | 0012
12771050 | 46449.5 | 0.00915951 | 15.7599 | ø300 mm | 0.001 | -2245.66 | -2299.66 | -2358.23 | 0.126083 | -2412.23 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | -2408.23 | 14.5925 | 100 | 18 | HT_PRIMÁR_přívodní | ø100 | 108 | 100 | TR02.01.0013 | 0013
12771604 | 371.57 | 0.00454772 | 0.0888332 | ø265 mm | 0.00145138 | -2449.59 | -2449.59 | -2821.16 |  | -2821.16 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | -2821.16 | 0.075876 | 65 | 17 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.0014 | 0014
12771793 | 45757.7 | 0.00915951 | 15.5252 | ø300 mm | 0.001 | -2245.95 | -2299.95 | -2357.65 | 0.126095 | -2411.65 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | -2407.65 | 14.3752 | 100 | 5 | HT_PRIMÁR_vratné | ø100 | 108 | 100 | TR02.01.0015 | 0015
12771889 | 381.798 | 0.00454772 | 0.0912785 | ø265 mm | 0.00145138 | -2449.01 | -2449.01 | -2830.81 |  | -2830.81 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | -2830.81 | 0.0779645 | 65 | 17 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.0016 | 0016
12773871 | 3112.23 | 0.00915951 | 1.05595 | ø300 mm | 0.001 | -2303.81 | -2357.81 | -2361.74 | 0.126096 | -2415.74 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | -2411.74 | 0.977735 | 100 | 19 | HT_PRIMÁR_vratné | ø100 | 108 | 100 | TR02.01.0017 | 0017
12773919 | 2663.37 | 0.00915951 | 0.903659 | ø300 mm | 0.001 | -2304.39 | -2358.39 | -2361.75 | 0.126083 | -2415.75 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | -2411.75 | 0.836721 | 100 | 20 | HT_PRIMÁR_přívodní | ø100 | 108 | 100 | TR02.01.0018 | 0018
12786563 | 9600.47 | 0.00454772 | 2.29523 | ø265 mm | 0.00145138 | -3450.48 | -3536.53 | -3488.53 | 0.5 | -3574.58 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | -3570.98 | 1.96045 | 65 | 17 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.0019 | 0019
12786566 | 49132.5 | 0.00454772 | 11.7464 | ø265 mm | 0.00145138 | -2822.8 | -3487.83 | -2860.85 | 1.2762 | -3525.87 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | -3522.27 | 10.033 | 65 | 17 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.0020 | 0020
12786603 | 9120.46 | 0.00454772 | 2.18048 | ø265 mm | 0.00145138 | -3449.96 | -3533.61 | -3488.01 | 0.5 | -3571.66 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | -3568.06 | 1.86243 | 65 | 17 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.0021 | 0021
12786606 | 48376.2 | 0.00454772 | 11.5655 | ø265 mm | 0.00145138 | -2832.45 | -3487.3 | -2870.49 | 1.27513 | -3525.35 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 1 | -3521.75 | 9.87859 | 65 | 17 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.0022 | 0022
