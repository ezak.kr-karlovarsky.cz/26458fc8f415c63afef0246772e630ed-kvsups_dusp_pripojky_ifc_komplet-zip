Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [VersionGUID: 07b3dc3b-3e19-438f-abfc-0c0998681948, NumberOfSaves: 232], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
File name: 220055
Time: 2023-10-13T16:47:06
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.6.0.0 - Alternate UI 22.6.0.0

# IfcProject, 220055
LongName: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Phase: DUSP

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Identifikační data - EBC_ID projektu: KVSUPS; EBC_ID stavebního objektu: "SO-XXX"; EBC_Zodpovědný projektant: Ing. Michal Pávek; EBC_Zpracovatel části: Energy Benefit Centre a.s.; EBC_Zpracovatel části adresa: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz internet: www.energy-benefit.cz; Název budovy: "NÁZEV STAVEBNÍHO OBJEKTU"; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz internet: www.energy-benefit.cz; Projektant: Ing. Lukáš Hovorka
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.2.4; EBC_Nadmořská výška: 389,970; EBC_Název profese: PŘÍPOJKA PLYNOVODU; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: PRP; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Stav projektu: DUSP

# IfcBuilding, "NÁZEV STAVEBNÍHO OBJEKTU"
LongName: "NÁZEV STAVEBNÍHO OBJEKTU"
Identifikační data - EBC_ID projektu: KVSUPS; EBC_ID stavebního objektu: "SO-XXX"; EBC_Zodpovědný projektant: Ing. Michal Pávek; EBC_Zpracovatel části: Energy Benefit Centre a.s.; EBC_Zpracovatel části adresa: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz internet: www.energy-benefit.cz; Název budovy: "NÁZEV STAVEBNÍHO OBJEKTU"; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz internet: www.energy-benefit.cz; Projektant: Ing. Lukáš Hovorka
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.2.4; EBC_Nadmořská výška: 389,970; EBC_Název profese: PŘÍPOJKA PLYNOVODU; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: PRP; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Stav projektu: DUSP

# IfcBuildingStorey: Podlaží:Podlaží (2)
In: "NÁZEV STAVEBNÍHO OBJEKTU"
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes
Jiné - Id typu: 305; Kategorie: Podlaží; Rodina: Podlaží; Rodina a typ: Podlaží: Podlaží; Typ: Podlaží
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Barva: 0; Symbol: EBC_Záhlaví podlaží : Běžné; Symbol na konci 1 – výchozí: yes; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: EB_Tečkovaná 1/50
Identifikační data(Type) - Název typu: Podlaží
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží
Name | LongName = Název | Elevation (mm) = Výška (mm)
-1.PP_SO-102 | -1.PP_SO-102 | -4000 | Vazby - Podlaží nad: 1.NP_SO-101,102
-1.PP_SO-101 | -1.PP_SO-101 | -3150

# IfcBuildingStorey: Podlaží:Podlaží ±0,000, 1.NP_SO-101,102
In: "NÁZEV STAVEBNÍHO OBJEKTU"
LongName: 1.NP_SO-101,102; Elevation: 7.58007e-12 mm
Vazby - Výška: 0 mm
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes; Název: 1.NP_SO-101,102
Jiné - Kategorie: Podlaží; Rodina: Podlaží; Id typu: 237447; Rodina a typ: Podlaží: Podlaží ±0,000; Typ: Podlaží ±0,000
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: EB_Tečkovaná 1/50; Barva: 16711935; Symbol: EBC_Záhlaví podlaží : +-0,000; Symbol na konci 1 – výchozí: no
Identifikační data(Type) - Název typu: Podlaží ±0,000
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží

# IfcBuildingElementProxy: HUP skříň1:HUP skříň, HUP skříň1:HUP skříň:12777172
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: AT00; Komentáře k typům: DOČASNÁ ZEMNÍ SOUPRAVA; Název typu: HUP skříň; Označení typu: 02
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: HUP skříň1
Classification: AT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.38833 m2; NetVolume: 0.220318 m3
Text - CCI Funkční systém: E; CCI Komponenta: UCA; CCI Technický systém: HA
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: -800 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.220318 m3; Plocha: 0.19418 m2
Identifikační data - Kód prvku: AT00.02.0002; Označení: 0002
Jiné - Páteřní trasa: yes; Typ: HUP skříň; Id typu: 12777170; Rodina: HUP skříň1; Rodina a typ: HUP skříň1: HUP skříň

# IfcBuildingElementProxy: HUP skříň:HUP skříň, HUP skříň:HUP skříň:12767506
In: -1.PP_SO-101
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: AT00; Komentáře k typům: PLYNOMĚRNÝ PILÍŘ; Název typu: HUP skříň; Označení typu: 01
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: HUP skříň
Classification: AT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.8994 m2; NetVolume: 0.452446 m3
Text - CCI Funkční systém: E; CCI Komponenta: UCA; CCI Technický systém: HA
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.452446 m3; Plocha: 0.42 m2
Identifikační data - Kód prvku: AT00.01.0001; Komentáře: SKŘÍŇ 1000×1000×420 mm; Označení: 0001
Jiné - Id typu: 12767504; Páteřní trasa: yes; Rodina: HUP skříň; Rodina a typ: HUP skříň: HUP skříň; Typ: HUP skříň

# IfcBuildingElementProxy: Závitový_Plynoměr.CC:Typ 10 - DN 50, průtok od 0,25 m3/h až 40 m3/h, ocel, ŠÍŘKA = 465mm, Závitový_Plynoměr.CC:Typ 10 - DN 50, průtok od 0,25 m3/h až 40 m3/h, ocel, ŠÍŘKA = 465mm:12778877
In: 1.NP_SO-101,102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; PRŮTOK_PLYN: 0 m3/s; SPÁD TLAKU: 0 Pa; TLAKOVÁ TŘÍDA: 16
Type - Kóty - Délka: 300 mm; HLOUBKA: 267 mm; JMENOVITÝ PRŮMĚR: 50 mm; Průměr připojení: 63 mm; ŠÍŘKA: 465 mm; VÝŠKA: 398 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: SZ04; Komentáře k typům: PLYNOMĚR G25; Model: Typ 10 - DN 50, průtok od 0,25 m3/h až 40 m3/h, ocel, ŠÍŘKA = 465mm; Název typu: Typ 10 - DN 50, průtok od 0,25 m3/h až 40 m3/h, ocel, ŠÍŘKA = 465mm; Označení typu: 03; Popis: Senzor; Popis sestavy: Plynoměr; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Mechanické zařízení; A: 335 mm; CM: 125.5 mm; DM: 449 mm; KOAX: no; KOAX_P: 0 mm; Lookup Table Name: Plynoměr; Název rodiny: Závitový_Plynoměr.CC; PR: 30 mm; PRIP: yes; PRIP_P: 1 mm; R: 105.5 mm; R5: 113.5 mm; SCH: 39.8 mm; TXT: 99.5 mm; Typ: 10 mm; VJ: 194 mm
Classification: SZ04 Uniformat (Uniformat); Group: GS_STL přípojka 1
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.15266 m2; NetVolume: 0.0407395 m3
Text - CCI Funkční systém: E; CCI Komponenta: PGF; CCI Technický systém: HA
Vazby - Podlaží: 1.NP_SO-101,102; Hostitel: Podlaží : 1.NP_SO-101,102; Odsazení od hostitele: -1582 mm; Výška od podlaží: -1582 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Ostatní; Název systému: GS_STL přípojka 1
Kóty - Objem: 0.00000886908 m3; Plocha: 0.00527281 m2
Identifikační data - Kód prvku: SZ04.03.0003; Komentáře: ROZTEČ 335 mm, Qmax=40 m3/h, DISPLEJ 1300 mm NAD TERÉNEM; Označení: 0003
Jiné - Páteřní trasa: yes; Id typu: 12770210; Rodina: Závitový_Plynoměr.CC; Rodina a typ: Závitový_Plynoměr.CC: Typ 10 - DN 50, průtok od 0,25 m3/h až 40 m3/h, ocel, ŠÍŘKA = 465mm; Typ: Typ 10 - DN 50, průtok od 0,25 m3/h až 40 m3/h, ocel, ŠÍŘKA = 465mm

# IfcDistributionPort (152)
Description: Flow
Name | FlowDirection | PredefinedType | SystemType | Group
Port_12764071_0 | SOURCEANDSINK | PIPE
Port_12764071_1 | SOURCEANDSINK | PIPE
Port_12764079_0 | SOURCEANDSINK | PIPE
Port_12764079_1 | SOURCEANDSINK | PIPE
Port_12764085_1 | SOURCEANDSINK | PIPE
Port_12764085_2 | SOURCEANDSINK | PIPE
Port_12764088_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1 (2)
Port_12784627_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1 (2)
Port_12764088_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1 (2)
Port_12765520_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1 (2)
Port_12764094_1 | SOURCEANDSINK | PIPE
Port_12764094_2 | SOURCEANDSINK | PIPE
Port_12764170_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL řad 1
Port_12765346_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL řad 1
Port_12764170_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL řad 1
Port_12764546_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL řad 1 (1) (1)
Port_12764546_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL řad 1 (1) (1)
Port_12779144_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL řad 1 (1) (1)
Port_12764582_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL řad 1 (1) (4)
Port_12766224_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL řad 1 (1) (4)
Port_12764582_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL řad 1 (1) (4)
Port_12765005_0 | SOURCEANDSINK | PIPE
Port_12765005_1 | SOURCEANDSINK | PIPE
Port_12765336_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL řad 1
Port_12765346_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL řad 1
Port_12765336_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL řad 1
Port_12765346_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL řad 1
Port_12779134_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL řad 1
Port_12765347_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1 (2)
Port_12765520_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1 (2)
InPort_12765347_1 | SINK | PIPE | USERDEFINED | GS_STL přípojka 1 (2)
OutPort_12779134_2 | SOURCE | PIPE | USERDEFINED | GS_STL přípojka 1 (2)
Port_12765847_0 | SOURCEANDSINK | PIPE
Port_12765847_1 | SOURCEANDSINK | PIPE
InPort_12765858_0 | SINK | PIPE | USERDEFINED | GS_NTL řad 1 (1) (2)
OutPort_12765873_1 | SOURCE | PIPE | USERDEFINED | GS_NTL řad 1 (1) (2)
Port_12765858_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL řad 1 (1) (2)
InPort_12765873_1 | SINK | PIPE | USERDEFINED | GS_NTL přípojka 1
OutPort_12765858_0 | SOURCE | PIPE | USERDEFINED | GS_NTL přípojka 1
Port_12765873_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL přípojka 1
Port_12765874_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL přípojka 1
Port_12765873_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL přípojka 1
Port_12765874_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL přípojka 1
Port_12765913_0 | SOURCEANDSINK | PIPE
Port_12765913_1 | SOURCEANDSINK | PIPE
Port_12765931_1 | SOURCEANDSINK | PIPE
Port_12765931_2 | SOURCEANDSINK | PIPE
Port_12765933_1 | SOURCEANDSINK | PIPE
Port_12765933_2 | SOURCEANDSINK | PIPE
Port_12765984_0 | SOURCEANDSINK | PIPE
Port_12765984_1 | SOURCEANDSINK | PIPE
Port_12766019_0 | SOURCEANDSINK | PIPE
Port_12766019_1 | SOURCEANDSINK | PIPE
Port_12766032_1 | SOURCEANDSINK | PIPE
Port_12766032_2 | SOURCEANDSINK | PIPE
Port_12766059_0 | SOURCEANDSINK | PIPE
Port_12766059_1 | SOURCEANDSINK | PIPE
Port_12766086_1 | SOURCEANDSINK | PIPE
Port_12766086_2 | SOURCEANDSINK | PIPE
Port_12766137_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL řad 1 (1) (1)
Port_12779144_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_NTL řad 1 (1) (1)
OutPort_12766137_2 | SOURCE | PIPE | USERDEFINED | GS_NTL řad 1 (1) (1)
OutPort_12766224_2 | SOURCE | PIPE | USERDEFINED | GS_NTL řad 1 (1) (4)
OutPort_12766224_3 | SOURCE | PIPE | USERDEFINED | GS_NTL řad 1 (1) (4)
Port_12777010_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1 (2)
Port_12784625_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1 (2)
OutPort_12777010_2 | SOURCE | PIPE | USERDEFINED | GS_STL přípojka 1 (2)
InPort_12778877_1 | SINK | PIPE | USERDEFINED | GS_STL přípojka 1
OutPort_12821620_0 | SOURCE | PIPE | USERDEFINED | GS_STL přípojka 1
InPort_12821773_0 | SINK | PIPE | USERDEFINED | GS_STL přípojka 1
OutPort_12778877_2 | SOURCE | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12778880_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12821604_4 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12778880_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12821962_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12778884_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12789154_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12778884_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12789084_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12778886_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12821763_4 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12778886_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12821953_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
InPort_12779134_2 | SINK | PIPE | USERDEFINED | GS_STL řad 1
OutPort_12765347_1 | SOURCE | PIPE | USERDEFINED | GS_STL řad 1
Port_12779168_1 | SOURCEANDSINK | PIPE
Port_12779168_2 | SOURCEANDSINK | PIPE
Port_12779268_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12789154_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12779268_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12780508_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12843933_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12780508_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12780582_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12780547_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12815278_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12780547_4 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12837312_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12780582_4 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12780687_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12780687_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12821962_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12781824_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12781935_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12781824_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12781839_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12815280_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12781839_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12781935_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12784517_0 | SOURCEANDSINK | PIPE
Port_12784517_1 | SOURCEANDSINK | PIPE
Port_12784580_0 | SOURCEANDSINK | PIPE
Port_12784580_1 | SOURCEANDSINK | PIPE
Port_12784625_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1 (2)
Port_12784627_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1 (2)
Port_12785763_1 | SOURCEANDSINK | PIPE
Port_12785763_2 | SOURCEANDSINK | PIPE
Port_12785792_0 | SOURCEANDSINK | PIPE
Port_12785792_1 | SOURCEANDSINK | PIPE
Port_12785802_0 | SOURCEANDSINK | PIPE
Port_12785802_1 | SOURCEANDSINK | PIPE
Port_12785804_1 | SOURCEANDSINK | PIPE
Port_12785804_2 | SOURCEANDSINK | PIPE
Port_12785806_1 | SOURCEANDSINK | PIPE
Port_12785806_2 | SOURCEANDSINK | PIPE
Port_12785851_0 | SOURCEANDSINK | PIPE
Port_12785851_1 | SOURCEANDSINK | PIPE
Port_12785853_1 | SOURCEANDSINK | PIPE
Port_12785853_2 | SOURCEANDSINK | PIPE
InPort_12789084_1 | SINK | PIPE | USERDEFINED | GS_STL přípojka 1
OutPort_12789087_1 | SOURCE | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12789084_3 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_12789087_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12821953_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12815278_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12815280_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12821604_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12821620_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12821763_3 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12821773_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12821953_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12821986_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12821962_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12821986_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12822035_3 | SOURCEANDSINK | PIPE
Port_12822035_4 | SOURCEANDSINK | PIPE
Port_12837312_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12837314_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12837314_2 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12843931_0 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12843931_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1
Port_12843933_1 | SOURCEANDSINK | PIPE | USERDEFINED | GS_STL přípojka 1

# IfcDistributionSystem: GS_NTL přípojka, GS_NTL přípojka 1
PredefinedType: USERDEFINED

# IfcDistributionSystem: GS_NTL řad (3)
PredefinedType: USERDEFINED
Name
GS_NTL řad 1 (1) (1)
GS_NTL řad 1 (1) (4)
GS_NTL řad 1 (1) (2)

# IfcDistributionSystem: GS_STL přípojka (2)
PredefinedType: USERDEFINED
Name
GS_STL přípojka 1 (2)
GS_STL přípojka 1

# IfcDistributionSystem: GS_STL řad, GS_STL řad 1
PredefinedType: USERDEFINED

# IfcPipeFitting: Chránička potrubí:Ocel (2)
In: 1.NP_SO-101,102
Type - Material: 255-192- 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: PO00; Komentáře k typům: CHRÁNIČKA; Nadpis OmniClass: Pipework Fittings; Název typu: Ocel; Označení typu: 05; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: Chránička potrubí; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: PO00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Vazby - Podlaží: 1.NP_SO-101,102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_STL přípojka; Klasifikace systému: Ostatní
Grafika - Použít měřítko poznámky: no
Jiné - Páteřní trasa: yes; Id typu: 12785476; Rodina: Chránička potrubí; Rodina a typ: Chránička potrubí: Ocel; Typ: Ocel
Name (Chránička potrubí:Ocel:...) | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Výška od podlaží (mm) | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Vnější poloměr tvarovky (mm)
12784627 | 7000 | 0.0519385 | 5.65557 | ø200 mm-ø200 mm | -3850 | GS_STL přípojka 1 (2) | 100 | 200 | 0.363601 | ø200-ø200 | 102.87 | 257.175 | PO00.05.0016 | 0016 | 128.588
12815280 | 1000 | 0.0190069 | 0.488753 | ø100 mm-ø100 mm | -2576.56 | GS_STL přípojka 1 | 50 | 100 | 0.0190085 | ø100-ø100 | 62.23 | 155.575 | PO00.05.0022 | 0022 | 77.7875 | Identifikační data - Komentáře: PROSTUPKA POTRUBÍ

# IfcPipeFitting: M_Koleno, obecné:Standardní (13)
In: 1.NP_SO-101,102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: K; Kód sestavy: TT01; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 01; Popis: Koleno; Popis sestavy: Koleno
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Koleno, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Vazby - Podlaží: 1.NP_SO-101,102
Grafika - Použít měřítko poznámky: no
Jiné - Id typu: 3326550; Rodina: M_Koleno, obecné; Rodina a typ: M_Koleno, obecné: Standardní; Typ: Standardní
Name (M_Koleno, obecné:Standardní:...) | Celková velikost | Výška od podlaží (mm) | Fáze demolice | Fáze vytvoření | Klasifikace systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Střední poloměr (mm) | Vnější poloměr tvarovky (mm)
12764085 | ø63 mm-ø63 mm | -3850 | Fáze 1 | Stávající stav | Nedefinovaný | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.01.0001 | 0001 | 39.4375 | 33.0875
12764094 | ø63 mm-ø63 mm | -3850 | Fáze 1 | Stávající stav | Nedefinovaný | 31.5 | 63 | 0.000210689 | 38.7551 | 89 | ø63-ø63 | 26.012 | 66.175 | TT01.01.0002 | 0002 | 39.4375 | 33.0875
12765520 | ø63 mm-ø63 mm | -3850 |  | Stávající stav | Ostatní | 31.5 | 63 | 0.000196441 | 34.88 | 82.9815 | ø63-ø63 | 23.4111 | 66.175 | TT01.01.0004 | 0004 | 39.4375 | 33.0875 | Mechanické - Typ systému: GS_STL přípojka; Název systému: GS_STL přípojka 1 (2); Group: GS_STL přípojka 1 (2)
12765931 | ø50 mm-ø50 mm | -4050 | Fáze 1 | Stávající stav | Nedefinovaný | 25 | 50 | 0.0000208263 | 4.5797 | 15.644 | ø50-ø50 | 2.9659 | 53.975 | TT01.01.0006 | 0006 | 33.3375 | 26.9875 | Fázování - Bouráno ve FÁZI 2: yes
12765933 | ø50 mm-ø50 mm | -4050 | Fáze 1 | Stávající stav | Nedefinovaný | 25 | 50 | 0.0000198526 | 4.36308 | 14.9125 | ø50-ø50 | 2.82562 | 53.975 | TT01.01.0007 | 0007 | 33.3375 | 26.9875 | Fázování - Bouráno ve FÁZI 2: yes
12766032 | ø50 mm-ø50 mm | -4050 | Fáze 1 | Stávající stav | Nedefinovaný | 25 | 50 | 0.000118335 | 32.6966 | 88.8879 | ø50-ø50 | 21.175 | 53.975 | TT01.01.0008 | 0008 | 33.3375 | 26.9875 | Fázování - Bouráno ve FÁZI 2: yes
12766086 | ø50 mm-ø50 mm | -4050 | Fáze 1 | Stávající stav | Nedefinovaný | 25 | 50 | 0.000121115 | 33.9099 | 90.9754 | ø50-ø50 | 21.9607 | 53.975 | TT01.01.0009 | 0009 | 33.3375 | 26.9875 | Fázování - Bouráno ve FÁZI 2: yes
12781935 | ø63 mm-ø63 mm | -3850 |  | Fáze 1 | Ostatní | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.01.0015 | 0015 | 39.4375 | 33.0875 | Mechanické - Typ systému: GS_STL přípojka; Název systému: GS_STL přípojka 1; Group: GS_STL přípojka 1; Jiné - Páteřní trasa: yes
12785763 | ø50 mm-ø50 mm | -3850 | Fáze 1 | Fáze 1 | Nedefinovaný | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0017 | 0017 | 33.3375 | 26.9875
12785804 | ø50 mm-ø50 mm | -3850 | Fáze 1 | Fáze 1 | Nedefinovaný | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0018 | 0018 | 33.3375 | 26.9875
12785806 | ø50 mm-ø50 mm | -1200 | Fáze 1 | Fáze 1 | Nedefinovaný | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0019 | 0019 | 33.3375 | 26.9875
12785853 | ø50 mm-ø50 mm | -1200 | Fáze 1 | Fáze 1 | Nedefinovaný | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0020 | 0020 | 33.3375 | 26.9875
12789154 | ø63 mm-ø63 mm | -1280 |  | Fáze 1 | Ostatní | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.01.0021 | 0021 | 39.4375 | 33.0875 | Mechanické - Typ systému: GS_STL přípojka; Název systému: GS_STL přípojka 1; Group: GS_STL přípojka 1; Jiné - Páteřní trasa: yes

# IfcPipeFitting: M_Přechod, obecný:Standardní (2)
In: 1.NP_SO-101,102
Type - Material: 255-192- 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT03; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 04; Popis: Redukce; Popis sestavy: Redukce
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT03 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Vazby - Podlaží: 1.NP_SO-101,102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Ostatní
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm; Viditelnost 1: no; Výškové odsazení: 3048 mm
Name (M_Přechod, obecný:Standardní:...) | Celková velikost | Výška od podlaží (mm) | Typ systému | Název systému | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – šířka = Odskok – výška | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Max. vnější průměr tvarovky 12 (mm) | Viditelnost 2 | Viditelnost 3 | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm) | Group
12779134 | ø110 mm-ø63 mm | -3850 | GS_STL řad | GS_STL řad 1 | 28.2938 | 55 | 31.5 | 110 | 63 | 110 | 63 | 0.000182688 | 0.0138179 | ø110-ø63 | 45.27 | 26.47 | 113.175 | 66.175 | TT03.04.0012 | 0012 | 113.175 | yes | no | 33.0875 | 56.5875 | GS_STL přípojka 1 (2); GS_STL řad 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
12779144 | ø225 mm-ø160 mm | -4050 | GS_NTL řad | GS_NTL řad 1 (1) (1) | 57.0438 | 80 | 112.5 | 160 | 225 | 225 | 160 | 0.00173093 | 0.0621043 | ø225-ø160 | 65.27 | 91.27 | 163.175 | 228.175 | TT03.04.0013 | 0013 | 228.175 | no | yes | 114.088 | 81.5875 | GS_NTL řad 1 (1) (1)

# IfcPipeFitting: M_Přechod, obecný:Standardní, M_Přechod, obecný:Standardní:12779168
In: 1.NP_SO-101,102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT03; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 04; Popis: Redukce; Popis sestavy: Redukce
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT03 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø63 mm-ø50 mm
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Vazby - Podlaží: 1.NP_SO-101,102; Výška od podlaží: -4050 mm
Fázování - Fáze demolice: Fáze 1; Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Nedefinovaný
Grafika - Použít měřítko poznámky: no
Kóty - Délka: 16.5437 mm; Jmenovitý poloměr 1: 31.5 mm; Jmenovitý poloměr 2: 25 mm; Jmenovitý průměr 1: 63 mm; Jmenovitý průměr 2: 50 mm; Maximální velikost: 63 mm; Minimální velikost: 50 mm; Objem: 0.000047016 m3; Odskok – šířka: 31.5; Odskok – výška: 31.5; Plocha: 0.00542487 m2; Velikost: ø63-ø50; Velikost značky 1: 26.47 mm; Velikost značky 2: 21.59 mm; Vnější průměr tvarovky 1: 66.175 mm; Vnější průměr tvarovky 2: 53.975 mm
Identifikační data - Kód prvku: TT03.04.0014; Označení: 0014
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm; Viditelnost 1: no; Viditelnost 2: yes; Viditelnost 3: no; Výškové odsazení: 3048 mm; DN tvarovky 1 (sdílený): 63 mm; DN tvarovky 2 (sdílený): 50 mm; Max. vnější průměr tvarovky 12: 66.175 mm; Vnější poloměr tvarovky 2: 26.9875 mm; Vnější proloměr tvarovky 1: 33.0875 mm

# IfcPipeFitting: M_Spoj T, obecný:Standardní (5)
In: 1.NP_SO-101,102
Type - Material: 255-192- 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT02; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 02; Popis: T kus; Popis sestavy: Odbočka
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT02 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Vazby - Podlaží: 1.NP_SO-101,102
Mechanické - Klasifikace systému: Ostatní
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní
Name (M_Spoj T, obecný:Standardní:...) | Celková velikost | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Úhel (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Úhel 1 (deg) = Úhel tvarovky 1 (sdílený) (deg) | Vnější poloměr tvarovky (mm) | Group
12765346 | ø110 mm-ø110 mm-ø110 mm | -3850 | Stávající stav | GS_STL řad | GS_STL řad 1 | 55 | 110 | 0.00160748 | 69.2875 | 92.0185 | ø110-ø110-ø110 | 45.27 | 113.175 | TT02.02.0003 | 0003 | 87.9815 | 56.5875 | GS_STL řad 1
12765873 | ø63 mm-ø63 mm-ø63 mm | -4050 | Stávající stav | GS_NTL přípojka | GS_NTL přípojka 1 | 31.5 | 63 | 0.000375824 | 45.7875 | 90.2686 | ø63-ø63-ø63 | 26.47 | 66.175 | TT02.02.0005 | 0005 | 89.7314 | 33.0875 | GS_NTL řad 1 (1) (2); GS_NTL přípojka 1 | Fázování - Bouráno ve FÁZI 2: yes
12766224 | ø225 mm-ø225 mm-ø225 mm | -4050 | Stávající stav | GS_NTL řad | GS_NTL řad 1 (1) (4) | 112.5 | 225 | 0.0115923 | 126.788 | 89.1667 | ø225-ø225-ø225 | 91.27 | 228.175 | TT02.02.0011 | 0011 | 89.1667 | 114.088 | GS_NTL řad 1 (1) (4)
12821953 | ø63 mm-ø63 mm-ø63 mm | -1280 | Fáze 1 | GS_STL přípojka | GS_STL přípojka 1 | 31.5 | 63 | 0.000375825 | 45.7875 | 90 | ø63-ø63-ø63 | 26.47 | 66.175 | TT02.02.0023 | 0023 | 90 | 33.0875 | GS_STL přípojka 1 | Jiné - Páteřní trasa: yes
12821962 | ø63 mm-ø63 mm-ø63 mm | -1280 | Fáze 1 | GS_STL přípojka | GS_STL přípojka 1 | 31.5 | 63 | 0.000375825 | 45.7875 | 90 | ø63-ø63-ø63 | 26.47 | 66.175 | TT02.02.0024 | 0024 | 90 | 33.0875 | GS_STL přípojka 1 | Jiné - Páteřní trasa: yes

# IfcPipeFitting: M_Spojka, obecná:Standardní (3)
In: 1.NP_SO-101,102
Type - Material: 255-192- 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: S; Kód sestavy: TT04; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: Spojení; Popis sestavy: Spojka
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spojka, obecná; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT04 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Vazby - Podlaží: 1.NP_SO-101,102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Ostatní
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 1484366; Rodina: M_Spojka, obecná; Rodina a typ: M_Spojka, obecná: Standardní
Name (M_Spojka, obecná:Standardní:...) | Length (mm) = Délka (mm) = Vnější poloměr tvarovky (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Výška od podlaží (mm) | Typ systému | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa
12766137 | 81.5875 | 0.0209093 | 0.0418241 | ø160 mm-ø160 mm | -4050 | GS_NTL řad | GS_NTL řad 1 (1) (1) | 80 | 160 | 0.00170608 | ø160-ø160 | 65.27 | 163.175 | TT04.03.0010 | 0010 | Mechanické – tok - Tlaková ztráta: 0 Pa
12837314 | 33.0875 | 0.0034389 | 0.00687872 | ø63 mm-ø63 mm | -1804.02 | GS_STL přípojka | GS_STL přípojka 1 | 31.5 | 63 | 0.000113794 | ø63-ø63 | 26.47 | 66.175 | TT04.03.0025 | 0025 | yes
12843933 | 33.0875 | 0.0034389 | 0.00687872 | ø63 mm-ø63 mm | -1456.57 | GS_STL přípojka | GS_STL přípojka 1 | 31.5 | 63 | 0.000113794 | ø63-ø63 | 26.47 | 66.175 | TT04.03.0026 | 0026 | yes

# IfcPipeSegment: Typy trubek:HDPE 100+_plynovod (27)
In: 1.NP_SO-101,102
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - Cena: 0; ID kategorie: TR; Kód sestavy: TR12; Komentáře k typům: POTRUBÍ V MÍSTĚ PRŮJEZDU STAVEBNÍCH STROJŮ OPATŘENO PROTI PONIČENÍ BETONOVÝMI ROZNÁŠECÍMI PROFILY; Model: PE100+; Název typu: HDPE 100+_plynovod; Označení typu: 01; Popis: HDPE 100+; Popis sestavy: High-density Polyethylene (HDPE); Výrobce: GCPlast
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR12 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Vazby - Horizontální zarovnání: Na střed; Referenční podlaží: 1.NP_SO-101,102; Vertikální zarovnání: Střed
Mechanické - Drsnost: 0.01 mm; Materiál: PE100+ ČERNÁ S ORANŽOVÝMI PRUHY; Typ přípoje: Obecné
Jiné - Id typu: 12488601; Rodina: Typy trubek; Rodina a typ: Typy trubek: HDPE 100+_plynovod; Typ: HDPE 100+_plynovod
Name (Typy trubek:HDPE 100+_plynovod:...) | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Sklon | Spodní výška (mm) | Fáze vytvoření | Klasifikace systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Material | Název systému | Typ systému | Group | Páteřní trasa
12764071 | 17703.2 | 0.00311678 | 3.50382 | ø63 mm | 0.000070922 | -3818.5 | -3850 | -3850 | 0 | -3881.5 | Stávající stav | Nedefinovaný | -3875.7 | HDPE 100+ SDR11 | 63 | 1 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0001 | 0001 | Mechanické – tok - Doplňkový průtok: 0 m3/s; Fázování - Fáze demolice: Fáze 1; Identifikační data - Komentáře: RUŠENÝ ÚSEK STL HDPE 63 - POTRUBÍ VYJMUTO - ŘEŠENO V RÁMCI DBP
12764079 | 3569.52 | 0.00311678 | 0.70648 | ø63 mm | 0.000070922 | -3818.5 | -3850 | -3850 | 0 | -3881.5 | Stávající stav | Nedefinovaný | -3875.7 | HDPE 100+ SDR11 | 63 | 1 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0002 | 0002 | Mechanické – tok - Doplňkový průtok: 0 m3/s; Fázování - Fáze demolice: Fáze 1
12764088 | 11.0069 | 0.00311678 | 0.00217849 | ø63 mm | 0.000070922 | -3818.5 | -3850 | -3850 | 0 | -3881.5 | Stávající stav | Ostatní | -3875.7 | HDPE 100+ SDR11 | 63 | 11 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0003 | 0003 | 255-192- 0 | GS_STL přípojka 1 (2) | GS_STL přípojka | GS_STL přípojka 1 (2) | Identifikační data - Komentáře: POTRUBÍ V MÍSTĚ PRŮJEZDU STAVEBNÍCH STROJŮ OPATŘENO PROTI PONIČENÍ OCELOVOU CHRÁNIČKOU
12764170 | 18052 | 0.00950189 | 6.23832 | ø110 mm | 0.000070922 | -3795 | -3850 | -3850 | 0 | -3905 | Stávající stav | Ostatní | -3898.4 | HDPE 100+ SDR17 | 110 | 9 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 17 - PN10 | SDR 17 - PN10 | ø110 | 96.8 | TR12.01.0004 | 0004 | 255-192- 0 | GS_STL řad 1 | GS_STL řad | GS_STL řad 1 | Identifikační data - Komentáře: STÁVAJÍCÍ STL HDPE 110
12764546 | 30762.9 | 0.0397548 | 21.745 | ø225 mm | 0.000070922 | -3937.5 | -4050 | -4050 | 0 | -4162.5 | Stávající stav | Ostatní | -4149.1 | HDPE 100+ SDR17 | 225 | 5 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 17 - PN10 | SDR 17 - PN10 | ø225 | 198.2 | TR12.01.0005 | 0005 | 255-192- 0 | GS_NTL řad 1 (1) (1) | GS_NTL řad | GS_NTL řad 1 (1) (1) | Identifikační data - Komentáře: STÁVAJÍCÍ NTL HDPE 225
12764582 | 75667.5 | 0.0397548 | 53.4862 | ø225 mm | 0.000070922 | -3937.5 | -4050 | -4050 | 0 | -4162.5 | Stávající stav | Ostatní | -4149.1 | HDPE 100+ SDR17 | 225 | 3 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 17 - PN10 | SDR 17 - PN10 | ø225 | 198.2 | TR12.01.0006 | 0006 | 255-192- 0 | GS_NTL řad 1 (1) (4) | GS_NTL řad | GS_NTL řad 1 (1) (4) | Identifikační data - Komentáře: STÁVAJÍCÍ NTL HDPE 225
12765005 | 28465.3 | 0.00311678 | 5.63386 | ø63 mm | 0.000070922 | -3818.5 | -3850 | -3850 | 0 | -3881.5 | Stávající stav | Nedefinovaný | -3875.7 | HDPE 100+ SDR11 | 63 | 1 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0007 | 0007 | Mechanické – tok - Doplňkový průtok: 0 m3/s; Fázování - Fáze demolice: Fáze 1; Identifikační data - Komentáře: RUŠENÝ ÚSEK STL HDPE 63 - POTRUBÍ VYJMUTO - ŘEŠENO V RÁMCI DBP
12765336 | 5330.71 | 0.00950189 | 1.84216 | ø110 mm | 0.000070922 | -3795 | -3850 | -3850 | 0 | -3905 | Stávající stav | Ostatní | -3898.4 | HDPE 100+ SDR17 | 110 | 10 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 17 - PN10 | SDR 17 - PN10 | ø110 | 96.8 | TR12.01.0008 | 0008 | 255-192- 0 | GS_STL řad 1 | GS_STL řad | GS_STL řad 1
12765347 | 28150.4 | 0.00311678 | 5.57155 | ø63 mm | 0.000070922 | -3818.5 | -3850 | -3850 | 0 | -3881.5 | Stávající stav | Ostatní | -3875.7 | HDPE 100+ SDR11 | 63 | 11 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0009 | 0009 | 255-192- 0 | GS_STL přípojka 1 (2) | GS_STL přípojka | GS_STL přípojka 1 (2); GS_STL řad 1 | Identifikační data - Komentáře: STÁVAJÍCÍ STL HDPE 63
12765858 | 16895.9 | 0.00311678 | 3.34405 | ø63 mm | 0.000070922 | -4018.5 | -4050 | -4050 | 0 | -4081.5 | Stávající stav | Ostatní | -4075.7 | HDPE 100+ SDR11 | 63 | 2 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0011 | 0011 | 255-192- 0 | GS_NTL řad 1 (1) (2) | GS_NTL řad | GS_NTL řad 1 (1) (2); GS_NTL přípojka 1 | Identifikační data - Komentáře: RUŠENÝ ÚSEK NTL HDPE 63 - ODBOČKA ZASLEPENA, ZAFOUKÁNO POPÍLKOBETONEM A KONCE ZASLEPENY - ŘEŠENO V RÁMCI DBP; Fázování - Bouráno ve FÁZI 2: yes
12765874 | 2516.63 | 0.00311678 | 0.498091 | ø63 mm | 0.000070922 | -4018.5 | -4050 | -4050 | 0 | -4081.5 | Stávající stav | Ostatní | -4075.7 | HDPE 100+ SDR11 | 63 | 9 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0012 | 0012 | 255-192- 0 | GS_NTL přípojka 1 | GS_NTL přípojka | GS_NTL přípojka 1 | Fázování - Bouráno ve FÁZI 2: yes
12778880 | 94.9313 | 0.00311678 | 0.0187888 | ø63 mm | 0.000194553 | -1325.79 | -1325.79 | -1420.72 |  | -1420.72 | Fáze 1 | Ostatní | -1420.72 | HDPE 100+ SDR11 | 63 | 5 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0017 | 0017 | 255-192- 0 | GS_STL přípojka 1 | GS_STL přípojka | GS_STL přípojka 1 | yes
12778884 | 37.9971 | 0.00311678 | 0.00752041 | ø63 mm | 0.000194553 | -1248.5 | -1280 | -1280 | 0 | -1311.5 | Fáze 1 | Ostatní | -1305.7 | HDPE 100+ SDR11 | 63 | 2 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0018 | 0018 | 255-192- 0 | GS_STL přípojka 1 | GS_STL přípojka | GS_STL přípojka 1 | yes
12778886 | 102.536 | 0.00311678 | 0.0202939 | ø63 mm | 0.000194553 | -1325.79 | -1325.79 | -1428.32 |  | -1428.32 | Fáze 1 | Ostatní | -1428.32 | HDPE 100+ SDR11 | 63 | 3 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0019 | 0019 | 255-192- 0 | GS_STL přípojka 1 | GS_STL přípojka | GS_STL přípojka 1 | yes
12779268 | 391.125 | 0.00311678 | 0.0774116 | ø63 mm | 0.000194553 | -1319.44 | -1710.56 | -1319.44 |  | -1710.56 | Fáze 1 | Ostatní | -1710.56 | HDPE 100+ SDR11 | 63 | 2 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0020 | 0020 | 255-192- 0 | GS_STL přípojka 1 | GS_STL přípojka | GS_STL přípojka 1 | yes
12780508 | 57.0215 | 0.00311678 | 0.0112857 | ø63 mm | 0.000194553 | -1383 | -1383 | -1440.02 |  | -1440.02 | Fáze 1 | Ostatní | -1440.02 | HDPE 100+ SDR11 | 63 | 1 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0021 | 0021 | 255-192- 0 | GS_STL přípojka 1 | GS_STL přípojka | GS_STL přípojka 1 | yes
12780687 | 61.2464 | 0.00311678 | 0.0121219 | ø63 mm | 0.000194553 | -1248.5 | -1280 | -1280 | 0 | -1311.5 | Fáze 1 | Ostatní | -1305.7 | HDPE 100+ SDR11 | 63 | 1 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0022 | 0022 | 255-192- 0 | GS_STL přípojka 1 | GS_STL přípojka | GS_STL přípojka 1 | yes
12781824 | 3586.88 | 0.00311678 | 0.709916 | ø63 mm | 0.000194553 | -3818.5 | -3850 | -3850 | 0 | -3881.5 | Fáze 1 | Ostatní | -3875.7 | HDPE 100+ SDR11 | 63 | 1 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0023 | 0023 | 255-192- 0 | GS_STL přípojka 1 | GS_STL přípojka | GS_STL přípojka 1 | yes
12781839 | 734 | 0.00311678 | 0.145274 | ø63 mm | 0.000194553 | -3076.56 | -3810.56 | -3076.56 |  | -3810.56 | Fáze 1 | Ostatní | -3810.56 | HDPE 100+ SDR11 | 63 | 1 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0024 | 0024 | 255-192- 0 | GS_STL přípojka 1 | GS_STL přípojka | GS_STL přípojka 1 | yes
12784625 | 204.097 | 0.00311678 | 0.040395 | ø63 mm | 0.000194553 | -3818.5 | -3850 | -3850 | 0 | -3881.5 | Stávající stav | Ostatní | -3875.7 | HDPE 100+ SDR11 | 63 | 11 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0027 | 0027 | 255-192- 0 | GS_STL přípojka 1 (2) | GS_STL přípojka | GS_STL přípojka 1 (2) | yes | Identifikační data - Komentáře: POTRUBÍ V MÍSTĚ PRŮJEZDU STAVEBNÍCH STROJŮ OPATŘENO PROTI PONIČENÍ OCELOVOU CHRÁNIČKOU
12789087 | 15.7779 | 0.00311678 | 0.00312276 | ø63 mm | 0.000194553 | -1248.5 | -1280 | -1280 | 0 | -1311.5 | Fáze 1 | Ostatní | -1305.7 | HDPE 100+ SDR11 | 63 | 2 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0031 | 0031 | 255-192- 0 | GS_STL přípojka 1 | GS_STL přípojka | GS_STL přípojka 1 | yes
12815278 | 70 | 0.00311678 | 0.0138544 | ø63 mm | 0.000194553 | -2006.56 | -2076.56 | -2006.56 |  | -2076.56 | Fáze 1 | Ostatní | -2076.56 | HDPE 100+ SDR11 | 63 | 1 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0032 | 0032 | 255-192- 0 | GS_STL přípojka 1 | GS_STL přípojka | GS_STL přípojka 1 | yes
12821620 | 35.2813 | 0.00311678 | 0.00698288 | ø63 mm | 0.000194553 | -1546.72 | -1546.72 | -1582 |  | -1582 | Fáze 1 | Ostatní | -1582 | HDPE 100+ SDR11 | 63 | 5 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0033 | 0033 | 255-192- 0 | GS_STL přípojka 1 | GS_STL přípojka | GS_STL přípojka 1 | yes
12821773 | 27.6769 | 0.00311678 | 0.00547781 | ø63 mm | 0.000194553 | -1554.32 | -1554.32 | -1582 |  | -1582 | Fáze 1 | Ostatní | -1582 | HDPE 100+ SDR11 | 63 | 3 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0034 | 0034 | 255-192- 0 | GS_STL přípojka 1 | GS_STL přípojka | GS_STL přípojka 1 | yes
12821986 | 243.425 | 0.00311678 | 0.0481788 | ø63 mm | 0.000194553 | -1248.5 | -1280 | -1280 | 0 | -1311.5 | Fáze 1 | Ostatní | -1305.7 | HDPE 100+ SDR11 | 63 | 4 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0035 | 0035 | 255-192- 0 | GS_STL přípojka 1 | GS_STL přípojka | GS_STL přípojka 1 | yes
12837312 | 59.9966 | 0.00311678 | 0.0118745 | ø63 mm | 0.000194553 | -1820.57 | -1820.57 | -1880.56 |  | -1880.56 | Fáze 1 | Ostatní | -1880.56 | HDPE 100+ SDR11 | 63 | 1 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0036 | 0036 | 255-192- 0 | GS_STL přípojka 1 | GS_STL přípojka | GS_STL přípojka 1 | yes
12843931 | 314.369 | 0.00311678 | 0.0622201 | ø63 mm | 0.000194553 | -1473.11 | -1473.11 | -1787.48 |  | -1787.48 | Fáze 1 | Ostatní | -1787.48 | HDPE 100+ SDR11 | 63 | 1 | PE100+ ČERNÁ S ORANŽOVÝMI PRUHY - SDR 11 - PN16 | SDR 11 - PN16 | ø63 | 51.4 | TR12.01.0037 | 0037 | 255-192- 0 | GS_STL přípojka 1 | GS_STL přípojka | GS_STL přípojka 1 | yes

# IfcPipeSegment: Typy trubek:Ocel_bralen (10)
In: 1.NP_SO-101,102
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR02; Název typu: Ocel_bralen; Označení typu: 02; Popis: OC Bralen; Popis sestavy: Ocel
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR02 Uniformat (Uniformat)
Qto_PipeSegmentBaseQuantities - GrossCrossSectionArea: 0.00285535 m2; NetCrossSectionArea: 0.00285535 m2
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø50 mm
Mechanické – tok - Doplňkový průtok: 0 m3/s
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Vazby - Horizontální zarovnání: Na střed; Referenční podlaží: 1.NP_SO-101,102; Vertikální zarovnání: Střed
Fázování - Fáze demolice: Fáze 1
Mechanické - Drsnost: 0.1 mm; Klasifikace systému: Nedefinovaný; Materiál: Kov, ocel; Popis úseku: BRALEN; Průměr: 50 mm; Typ přípoje: Obecné; Úsek potrubí: Kov, ocel - Bralen; Výkaz/typ: Bralen
Kóty - Velikost: ø50; Vnější průměr: 60.3 mm; Vnitřní průměr: 53 mm
Jiné - Rodina: Typy trubek; Id typu: 12487575; Rodina a typ: Typy trubek: Ocel_bralen; Typ: Ocel_bralen
Name (Typy trubek:Ocel_bralen:...) | Length (mm) = Délka (mm) | OuterSurfaceArea (m2) | Relativní drsnost | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Obrátit výšku (mm) | Plocha (m2) | Řez | Kód prvku | Označení
12765847 | 3215.98 | 0.609228 | 0.000070922 | 0 | -4019.85 | -4050 | -4050 | -4080.15 | Stávající stav | -4076.5 | 0.505165 | 12 | TR02.02.0010 | 0010 | Fázování - Bouráno ve FÁZI 2: yes
12765913 | 13482.2 | 2.55404 | 0.000070922 | 0 | -4019.85 | -4050 | -4050 | -4080.15 | Stávající stav | -4076.5 | 2.11778 | 12 | TR02.02.0013 | 0013 | Fázování - Bouráno ve FÁZI 2: yes
12765984 | 12147.7 | 2.30123 | 0.000070922 | 0 | -4019.85 | -4050 | -4050 | -4080.15 | Stávající stav | -4076.5 | 1.90815 | 12 | TR02.02.0014 | 0014 | Fázování - Bouráno ve FÁZI 2: yes; Identifikační data - Komentáře: RUŠENÝ ÚSEK NTL OCEL DN50 - ODBOČKA ZASLEPENA, ČÁST POTRUBÍ OD STAVEBNÍ JÁMY K OBJEKTU VYJMUTÁ, ZBYTEK ZAFOUKÁNO POPÍLKOBETONEM A KONCE ZASLEPENY - ŘEŠENO V RÁMCI DBP
12766019 | 1978.86 | 0.374872 | 0.000070922 | 0 | -4019.85 | -4050 | -4050 | -4080.15 | Stávající stav | -4076.5 | 0.310839 | 12 | TR02.02.0015 | 0015 | Fázování - Bouráno ve FÁZI 2: yes
12766059 | 18308.8 | 3.46839 | 0.000070922 | 0 | -4019.85 | -4050 | -4050 | -4080.15 | Stávající stav | -4076.5 | 2.87595 | 12 | TR02.02.0016 | 0016 | Fázování - Bouráno ve FÁZI 2: yes; Identifikační data - Komentáře: RUŠENÝ ÚSEK NTL OCEL DN50 - POTRUBÍ VYJMUTO - ŘEŠENO V RÁMCI DBP
12784517 | 2862.77 | 0.542317 | 0.000194553 | 0 | -3819.85 | -3850 | -3850 | -3880.15 | Fáze 1 | -3876.5 | 0.449682 | 1 | TR02.02.0025 | 0025
12784580 | 5077.7 | 0.961909 | 0.000194553 | 0 | -3819.85 | -3850 | -3850 | -3880.15 | Fáze 1 | -3876.5 | 0.797603 | 1 | TR02.02.0026 | 0026
12785792 | 358.325 | 0.0678804 | 0.000194553 | 0 | -1169.85 | -1200 | -1200 | -1230.15 | Fáze 1 | -1226.5 | 0.0562856 | 1 | TR02.02.0028 | 0028 | Identifikační data - Komentáře: DOČASNÁ OCELOVÁ ČICHAČKA
12785802 | 2583.33 | 0.48938 | 0 |  | -1233.34 | -1233.34 | -3816.66 | -3816.66 | Fáze 1 | -3816.66 | 0.405788 | 1 | TR02.02.0029 | 0029
12785851 | 446.663 | 0.0846149 | 0 |  | -1233.34 | -1680 | -1233.34 | -1680 | Fáze 1 | -1680 | 0.0701616 | 1 | TR02.02.0030 | 0030

# IfcValve: Bezpečnostní uzávěr BAP:DN65, Bezpečnostní uzávěr BAP:DN65:12789084
In: 1.NP_SO-101,102
Type - Material: Color RGB 045-045-045, Color RGB 140-140-140, Color RGB 168-128-048
Type - Elektroinstalace – zatížení - Voltage: 230 V
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Pressure Stage: 0 mm
Type - Materiály a povrchové úpravy - Black: Color RGB 045-045-045; Grey: Color RGB 140-140-140; Yellow: Color RGB 168-128-048
Type - Kóty - Jmenovitá velikost vstupu: 65 mm; Jmenovitá velikost výstupu: 65 mm; Use Nominal Diameter: yes
Type - Identifikační data - Article Description: Generic valve; Article Type: Generic Valve; Číslo OmniClass: 23.65.55.14; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; EMCS Version: 3.0; ETIM Article Class: EC010120; Family Version: 11.14; Kód sestavy: VE25; Komentáře k typům: BAP; MEPcontent Class: VALVE; Model: Generic Valve; Nadpis OmniClass: Valves for Liquid Services; Název typu: DN65; Označení typu: 04; Popis: Generic valve; Popis sestavy: Automatický bezpečnostní uzávěr; Revit Version: 2018; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Bezpečnostní uzávěr BAP
Classification: VE25 Uniformat (Uniformat); Group: GS_STL přípojka 1
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø63 mm-ø63 mm
Elektroinstalace – zatížení - Power: 0 W
Text - CCI Funkční systém: E; CCI Komponenta: QMA; CCI Technický systém: HA
Vazby - Podlaží: 1.NP_SO-101,102; Actual Offset: 10 mm; Negative Offset: 10 mm; Výška od podlaží: -1280 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_STL přípojka; Flow 1: 0 m3/s; Flow 2: 0 m3/s; Klasifikace systému: Ostatní,Napájení; Název systému: GS_STL přípojka 1
Elektrotechnika - Phase: 1
Grafika - Použít měřítko poznámky: no; Annotation Offset: 0 mm
Kóty - Depth: 77 mm; Diameter: 63 mm; Height: 192 mm; Length: 156 mm; Maximální velikost: 63 mm; Minimální velikost: 63 mm; Objem: 0.0017913 m3; Velikost: ø63-ø63
Identifikační data - Kód prvku: VE25.04.0004; Komentáře: BEZ NAPÁJENÍ VYPNUTO, ON/OFF V SOUVISLOSTI NA HAVARIJNÍCH STAVECH - POŽÁR, ÚNIK PLYNU, ZAPLAVENÍ, VÝPADEK PROUDU, ...(VE SPOLUPRÁCI S EPS); Označení: 0004
Jiné - Páteřní trasa: yes; Control Depth: 69 mm; Control Radius: 34.5 mm; Flange Length: 98 mm; Id typu: 12788986; M: 131 mm; Outer Diameter: 60.3 mm; Outer Radius: 30.15 mm; Radius: 46 mm; Rodina: Bezpečnostní uzávěr BAP; Rodina a typ: Bezpečnostní uzávěr BAP: DN65; Typ: DN65

# IfcValve: Přirubový_Uzavírací ventil 2.CC:DN50, Přirubový_Uzavírací ventil 2.CC:DN50:12777010
In: 1.NP_SO-101,102
Type - Material: 255-192- 0
Type - Text - PALCOVÉ JEDNOTKY: 2"
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - TLAKOVÁ TŘÍDA: 16
Type - Grafika - Příruba: Plochá_nesdílená : PN16
Type - Kóty - DÉLKA: 180 mm; Jmenovitá velikost vstupu: 50 mm; Jmenovitá velikost výstupu: 50 mm; JMENOVITÝ PRŮMĚR: 50 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VE05; Komentáře k typům: kulový DN50; Model: DN50; Název typu: DN50; Označení typu: 01; Popis: Ventil; Popis sestavy: Uzavírací klapka; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; Armatura_Průměr: 51 mm; B: 34.5 mm; C: 795 mm; E: 28.75 mm; Lookup Table Name: Ventil kulový.CC; Název rodiny: Přirubový_Uzavírací ventil 2.CC; Tělo_Délka: 144 mm; Tělo_Průměr: 57.5 mm; U: 30 deg; Uzávěr_Délka: 160 mm; Ventil_Výška: 800 mm; Z: 80 mm
Classification: VE05 Uniformat (Uniformat); Group: GS_STL přípojka 1 (2)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø63 mm-ø63 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: E; CCI Komponenta: QMA; CCI Technický systém: HA
Vazby - Podlaží: 1.NP_SO-101,102; Výška od podlaží: -3850 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_STL přípojka; Klasifikace systému: Ostatní; Název systému: GS_STL přípojka 1 (2); PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no; PROTIPŘÍRUBA 1: Plochá : PN16; PROTIPŘÍRUBA 2: Plochá : PN16
Kóty - Maximální velikost: 63 mm; Minimální velikost: 63 mm; Objem: 0.00145936 m3; Průměr připojení: 63 mm; Velikost: ø63-ø63
Identifikační data - Kód prvku: VE05.01.0001; Označení: 0001
Jiné - Páteřní trasa: yes; Id typu: 12776983; Rodina: Přirubový_Uzavírací ventil 2.CC; Rodina a typ: Přirubový_Uzavírací ventil 2.CC: DN50; Typ: DN50

# IfcValve: Závitový_G_Ventil kulový.CC:DN 50 (3)
In: 1.NP_SO-101,102
Type - Material: 255-192- 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_PLYN: 0 m3/s; SPÁD TLAKU: 0 Pa; TLAKOVÁ TŘÍDA: 16
Type - Kóty - DÉLKA: 126 mm; Jmenovitá velikost vstupu: 50 mm; Jmenovitá velikost výstupu: 50 mm; JMENOVITÝ PRŮMĚR: 50 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.65.55.17.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VE01; Komentáře k typům: KK G2"; Model: DN 50; Nadpis OmniClass: Adjusting/Controlling Valves for Gas Supplies; Název typu: DN 50; Označení typu: 05; Popis sestavy: Kulový kohout; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; 05D: 63 mm; DD: 126 mm; Lookup Table Name: G_Ventil kulový.CC; Název rodiny: Závitový_G_Ventil kulový.CC
Classification: VE01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø63 mm-ø63 mm
Text - CCI Funkční systém: E; CCI Komponenta: QMA; CCI Technický systém: HA
Vazby - Podlaží: 1.NP_SO-101,102
Fázování - Fáze vytvoření: Fáze 1
Kóty - Maximální velikost: 63 mm; Minimální velikost: 63 mm; Objem: 0.000246947 m3; Průměr připojení: 63 mm; Velikost: ø63-ø63
Identifikační data - Popis: G_Ventil
Jiné - Páteřní trasa: yes; Angle3: 30 deg; Rodina: Závitový_G_Ventil kulový.CC; A: 50 mm; Angle1: 20 deg; Angle2: 22.5 deg; B: 28.5 mm; B2: 40.6303 mm; Ch: 66 mm; CW: 38.5 mm; D: 81 mm; D1: 44.8721 mm; D2: 21.2 mm; D3: 26.2 mm; D4: 37.5375 mm; E: 143 mm; Id typu: 12780369; Rodina a typ: Závitový_G_Ventil kulový.CC: DN 50; Typ: DN 50
Name (Závitový_G_Ventil kulový.CC:DN 50:...) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Použít měřítko poznámky | Kód prvku | Označení
12821604 | -1420.72 | GS_STL přípojka | Ostatní | GS_STL přípojka 1 | yes | VE01.05.0005 | 0005
12821763 | -1428.32 | GS_STL přípojka | Ostatní | GS_STL přípojka 1 | no | VE01.05.0006 | 0006
12822035 | -1280 |  | Nedefinovaný |  | no | VE01.05.0007 | 0007 | Identifikační data - Komentáře: ZAPLOMBOVÁNO

# IfcValve: Závitový_G_Ventil kulový.CC:DN 50_HUP, Závitový_G_Ventil kulový.CC:DN 50_HUP:12780547
In: 1.NP_SO-101,102
Type - Material: 255-192- 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_PLYN: 0 m3/s; SPÁD TLAKU: 0 Pa; TLAKOVÁ TŘÍDA: 16
Type - Kóty - DÉLKA: 126 mm; Jmenovitá velikost vstupu: 50 mm; Jmenovitá velikost výstupu: 50 mm; JMENOVITÝ PRŮMĚR: 50 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.65.55.17.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VE01; Komentáře k typům: HUP KK G2"; Model: DN 50; Nadpis OmniClass: Adjusting/Controlling Valves for Gas Supplies; Název typu: DN 50_HUP; Označení typu: 02; Popis sestavy: Kulový kohout; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; 05D: 63 mm; DD: 126 mm; Lookup Table Name: G_Ventil kulový.CC; Název rodiny: Závitový_G_Ventil kulový.CC
Classification: VE01 Uniformat (Uniformat); Group: GS_STL přípojka 1
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø63 mm-ø63 mm
Text - CCI Funkční systém: E; CCI Komponenta: QMA; CCI Technický systém: HA
Vazby - Podlaží: 1.NP_SO-101,102; Výška od podlaží: -1880.56 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_STL přípojka; Klasifikace systému: Ostatní; Název systému: GS_STL přípojka 1
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 63 mm; Minimální velikost: 63 mm; Objem: 0.000246947 m3; Průměr připojení: 63 mm; Velikost: ø63-ø63
Identifikační data - Kód prvku: VE01.02.0002; Označení: 0002; Popis: G_Ventil
Jiné - Páteřní trasa: yes; A: 50 mm; Angle1: 20 deg; Angle2: 22.5 deg; Angle3: 30 deg; B: 28.5 mm; B2: 40.6303 mm; Ch: 66 mm; CW: 38.5 mm; D: 81 mm; D1: 44.8721 mm; D2: 21.2 mm; D3: 26.2 mm; D4: 37.5375 mm; E: 143 mm; Id typu: 12898575; Rodina: Závitový_G_Ventil kulový.CC; Rodina a typ: Závitový_G_Ventil kulový.CC: DN 50_HUP; Typ: DN 50_HUP

# IfcValve: Závitový_Regulátor domovní_B10,25,40.CC:B40, Závitový_Regulátor domovní_B10,25,40.CC:B40:12780582
In: 1.NP_SO-101,102
Type - Material: 255-192- 0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_PLYN: 0 m3/s; SPÁD TLAKU: 0 Pa; TLAKOVÁ TŘÍDA: 16
Type - Kóty - DÉLKA: 103 mm; Jmenovitá velikost vstupu: 40 mm; Jmenovitá velikost výstupu: 40 mm; JMENOVITÝ PRŮMĚR 1: 20 mm; JMENOVITÝ PRŮMĚR 2: 32 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VE06; Komentáře k typům: REGULÁTOR B40; Model: B40; Název typu: B40; Označení typu: 03; Popis: Regulátor; Popis sestavy: Regulační; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Závitový_Regulátor domovní_B10,25,40.CC
Classification: VE06 Uniformat (Uniformat); Group: GS_STL přípojka 1
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø63 mm-ø63 mm
Text - CCI Funkční systém: E; CCI Komponenta: QMA; CCI Technický systém: HA
Vazby - Podlaží: 1.NP_SO-101,102; Výška od podlaží: -1280 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_STL přípojka; Klasifikace systému: Ostatní; Název systému: GS_STL přípojka 1
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 63 mm; Minimální velikost: 63 mm; Objem: 0.000765311 m3; Průměr připojení 1: 63 mm; Průměr připojení 2: 63 mm; Velikost: ø63-ø63
Identifikační data - Kód prvku: VE06.03.0003; Komentáře: VÝSTUP 3 kPa; Označení: 0003
Jiné - Páteřní trasa: yes; Id typu: 12768874; Rodina: Závitový_Regulátor domovní_B10,25,40.CC; Rodina a typ: Závitový_Regulátor domovní_B10,25,40.CC: B40; Typ: B40
