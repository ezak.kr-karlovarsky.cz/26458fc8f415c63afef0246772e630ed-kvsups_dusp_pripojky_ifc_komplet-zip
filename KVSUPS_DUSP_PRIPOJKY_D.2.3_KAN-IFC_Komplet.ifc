Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [VersionGUID: 32ac997c-e2d1-45bb-a195-591b4da267b9, NumberOfSaves: 292], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
File name: 220055
Time: 2023-10-13T16:47:05
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.6.0.0 - Alternate UI 22.6.0.0

# IfcProject, 220055
LongName: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Phase: DUSP

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Identifikační data - EBC_ID projektu: KVSUPS; EBC_ID stavebního objektu: "SO-XXX"; EBC_Zodpovědný projektant: Ing. Michal Pávek; EBC_Zpracovatel části: Energy Benefit Centre a.s.; EBC_Zpracovatel části adresa: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz internet: www.energy-benefit.cz; Název budovy: "NÁZEV STAVEBNÍHO OBJEKTU"; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz internet: www.energy-benefit.cz; Projektant: Ing. Lukáš Hovorka
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.2.3; EBC_Nadmořská výška: 389,970; EBC_Název profese: PŘÍPOJKA KANALIZACE; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: PRK; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Stav projektu: DUSP

# IfcBuilding, "NÁZEV STAVEBNÍHO OBJEKTU"
LongName: "NÁZEV STAVEBNÍHO OBJEKTU"
Identifikační data - EBC_ID projektu: KVSUPS; EBC_ID stavebního objektu: "SO-XXX"; EBC_Zodpovědný projektant: Ing. Michal Pávek; EBC_Zpracovatel části: Energy Benefit Centre a.s.; EBC_Zpracovatel části adresa: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz internet: www.energy-benefit.cz; Název budovy: "NÁZEV STAVEBNÍHO OBJEKTU"; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz internet: www.energy-benefit.cz; Projektant: Ing. Lukáš Hovorka
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.2.3; EBC_Nadmořská výška: 389,970; EBC_Název profese: PŘÍPOJKA KANALIZACE; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: PRK; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Stav projektu: DUSP

# IfcBuildingStorey: Podlaží:Podlaží (2)
In: "NÁZEV STAVEBNÍHO OBJEKTU"
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes
Jiné - Id typu: 305; Kategorie: Podlaží; Rodina: Podlaží; Rodina a typ: Podlaží: Podlaží; Typ: Podlaží
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Barva: 0; Symbol: EBC_Záhlaví podlaží : Běžné; Symbol na konci 1 – výchozí: yes; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: EB_Tečkovaná 1/50
Identifikační data(Type) - Název typu: Podlaží
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží
Name | LongName = Název | Elevation (mm) = Výška (mm)
-1.PP_SO-102 | -1.PP_SO-102 | -4000 | Vazby - Podlaží nad: 1.NP_SO-101,102
-1.PP_SO-101 | -1.PP_SO-101 | -3150

# IfcBuildingStorey: Podlaží:Podlaží ±0,000, 1.NP_SO-101,102
In: "NÁZEV STAVEBNÍHO OBJEKTU"
LongName: 1.NP_SO-101,102; Elevation: 7.58007e-12 mm
Vazby - Výška: 0 mm
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes; Název: 1.NP_SO-101,102
Jiné - Kategorie: Podlaží; Rodina: Podlaží; Id typu: 237447; Rodina a typ: Podlaží: Podlaží ±0,000; Typ: Podlaží ±0,000
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: EB_Tečkovaná 1/50; Barva: 16711935; Symbol: EBC_Záhlaví podlaží : +-0,000; Symbol na konci 1 – výchozí: no
Identifikační data(Type) - Název typu: Podlaží ±0,000
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží

# IfcDistributionPort (149)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection | SystemType | Group
Port_12765154_0 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784007_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12765154_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12765635_0 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784085_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12765635_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784087_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12766152_0 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12781091_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12766152_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12776020_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12781092_0 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12776020_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784007_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12776020_3 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784069_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12776254_0 | SOURCEANDSINK | SEWAGE | SW_Splašky přípojka 2
Port_12776254_1 | SOURCEANDSINK | SEWAGE | SW_Splašky přípojka 2
Port_12780937_1 | SOURCEANDSINK | SEWAGE | SW_Splašky přípojka 2
Port_12777797_0 | SOURCEANDSINK | SEWAGE | SW_Splašky přípojka 3
Port_12777797_1 | SOURCEANDSINK | SEWAGE | SW_Splašky přípojka 3
Port_12779062_0 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779113_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779062_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779091_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779072_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784071_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779072_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784073_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779072_3 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779557_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779073_0 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784069_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779073_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784071_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779079_0 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779091_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779079_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779103_0 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779113_3 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779103_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779113_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779114_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779114_0 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779557_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779146_0 | SOURCEANDSINK
Port_12779146_1 | SOURCEANDSINK
Port_12779156_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784075_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779156_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784077_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779156_3 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779559_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779191_0 | SOURCEANDSINK
Port_12779191_1 | SOURCEANDSINK
Port_12779201_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784079_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779201_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784081_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779201_3 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779561_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779202_0 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784077_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779202_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784079_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779231_0 | SOURCEANDSINK
Port_12779231_1 | SOURCEANDSINK
Port_12779241_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784083_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779241_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784085_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779241_3 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779563_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779242_0 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784081_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779242_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784083_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779260_0 | SOURCEANDSINK
Port_12779260_1 | SOURCEANDSINK
Port_12779271_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784087_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779271_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779559_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779561_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12779563_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12780927_0 | SOURCEANDSINK | SEWAGE | SW_Splašky přípojka 2
Port_12833364_2 | SOURCEANDSINK | SEWAGE | SW_Splašky přípojka 2
Port_12780927_1 | SOURCEANDSINK | SEWAGE | SW_Splašky přípojka 2
Port_12780937_2 | SOURCEANDSINK | SEWAGE | SW_Splašky přípojka 2
Port_12833362_0 | SOURCEANDSINK | SEWAGE | SW_Splašky přípojka 2
Port_12781091_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12781092_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
InPort_12781091_3 | SINK | SEWAGE | SW_Splašky řad 1
OutPort_12783911_1 | SOURCE | SEWAGE | SW_Splašky řad 1
Port_12781096_0 | SOURCEANDSINK
Port_12781096_1 | SOURCEANDSINK
InPort_12783911_2 | SINK | SEWAGE | SW_Splašky řad 1
OutPort_12858807_0 | SOURCE | SEWAGE | SW_Splašky řad 1
Port_12784073_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12849700_0 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12784075_2 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12849700_1 | SOURCEANDSINK | SEWAGE | SW_Splašky řad 1
Port_12833362_1 | SOURCEANDSINK | SEWAGE | SW_Splašky přípojka 2
Port_12833364_1 | SOURCEANDSINK | SEWAGE | SW_Splašky přípojka 2
InPort_12859631_1 | SINK | SEWAGE | SW_Deště přípojka 3
OutPort_12857755_1 | SOURCE | SEWAGE | SW_Deště přípojka 3
InPort_12865726_2 | SINK | SEWAGE | SW_Deště přípojka 3
OutPort_12858366_0 | SOURCE | SEWAGE | SW_Deště přípojka 3
InPort_12858366_1 | SINK | SEWAGE | SW_Deště přípojka 3
OutPort_12865176_2 | SOURCE | SEWAGE | SW_Deště přípojka 3
InPort_12859631_2 | SINK | SEWAGE | SW_Deště přípojka 3
OutPort_12858378_0 | SOURCE | SEWAGE | SW_Deště přípojka 3
InPort_12858378_1 | SINK | SEWAGE | SW_Deště přípojka 3
OutPort_12865172_1 | SOURCE | SEWAGE | SW_Deště přípojka 3
InPort_12858807_1 | SINK | SEWAGE | SW_Splašky řad 1
OutPort_12865055_1 | SOURCE | SEWAGE | SW_Splašky řad 1
InPort_12857755_1 | SINK | SEWAGE | SW_Deště přípojka 3
OutPort_12859631_1 | SOURCE | SEWAGE | SW_Deště přípojka 3
InPort_12865740_2 | SINK | SEWAGE | SW_Deště přípojka 3
OutPort_12864954_0 | SOURCE | SEWAGE | SW_Deště přípojka 3
InPort_12865028_1 | SINK | SEWAGE | SW_Splašky řad 1
OutPort_12864954_1 | SOURCE | SEWAGE | SW_Splašky řad 1
InPort_12864978_0 | SINK | SEWAGE | SW_Splašky řad 1
OutPort_12865028_2 | SOURCE | SEWAGE | SW_Splašky řad 1
InPort_12865055_2 | SINK | SEWAGE | SW_Splašky řad 1
OutPort_12864978_1 | SOURCE | SEWAGE | SW_Splašky řad 1
InPort_12865159_0 | SINK | SEWAGE | SW_Deště přípojka 3
OutPort_12865161_2 | SOURCE | SEWAGE | SW_Deště přípojka 3
InPort_12865176_1 | SINK | SEWAGE | SW_Deště přípojka 3
OutPort_12865159_1 | SOURCE | SEWAGE | SW_Deště přípojka 3
InPort_12865161_1 | SINK | SEWAGE | SW_Deště přípojka 3
OutPort_12865740_1 | SOURCE | SEWAGE | SW_Deště přípojka 3
InPort_12865172_2 | SINK | SEWAGE | SW_Deště přípojka 3
OutPort_12865726_1 | SOURCE | SEWAGE | SW_Deště přípojka 3
Port_12866303_0 | SOURCEANDSINK
Port_12866303_1 | SOURCEANDSINK
InPort_12870504_1 | SINK | SEWAGE | SW_Deště přípojka 1
OutPort_12870493_1 | SOURCE | SEWAGE | SW_Deště přípojka 1
InPort_12870494_0 | SINK | SEWAGE | SW_Deště přípojka 1
OutPort_12870504_2 | SOURCE | SEWAGE | SW_Deště přípojka 1
InPort_12870865_1 | SINK | SEWAGE | SW_Deště přípojka 1
OutPort_12870494_1 | SOURCE | SEWAGE | SW_Deště přípojka 1
InPort_12870681_0 | SINK | SEWAGE | SW_Deště přípojka 1
OutPort_12870870_1 | SOURCE | SEWAGE | SW_Deště přípojka 1
OutPort_12870681_1 | SOURCE | SEWAGE | SW_Deště přípojka 1
InPort_12870683_0 | SINK | SEWAGE | SW_Deště přípojka 1
OutPort_12870865_2 | SOURCE | SEWAGE | SW_Deště přípojka 1
InPort_12870870_2 | SINK | SEWAGE | SW_Deště přípojka 1
OutPort_12870683_1 | SOURCE | SEWAGE | SW_Deště přípojka 1

# IfcDistributionSystem: SW_Deště přípojka (2)
PredefinedType: SEWAGE
Name
SW_Deště přípojka 3
SW_Deště přípojka 1

# IfcDistributionSystem: SW_Splašky přípojka (2)
PredefinedType: SEWAGE
Name
SW_Splašky přípojka 2
SW_Splašky přípojka 3

# IfcDistributionSystem: SW_Splašky řad, SW_Splašky řad 1
PredefinedType: SEWAGE

# IfcFlowTerminal: Uliční vpusť:DN110, Uliční vpusť:DN110:12857755
In: 1.NP_SO-101,102
Type - Material: Plactic - Black, Plactic - White, Cast iron, Plactic - Gray
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 300 mm; Jmenovitá velikost výstupu: 110 mm; JMENOVITÝ PRŮMĚR: 110 mm; Šířka: 300 mm; Výška: 500 mm
Type - Identifikační data - Číslo OmniClass: 23.70.50.21.24.14; DIMENZE: DN110; EAN: 9003076960613; HMOTNOST: 11,879 kg; HYDRAULICKÁ KAPACITA: 4,3 l/s; Indexovaná poznámka: HL606.1/1; Kód sestavy: VP04; Komentáře k typům: ULIČNÍ VPUST - UV2; MATERIÁL: PP; Model: HL606.1/1; Nadpis OmniClass: Deck Waste Water Drains; NÁSTAVEC: 260 x 260 mm Guss; Název typu: DN110; Označení typu: 01; Popis: Perfekt dvorní vtok DN110 se svislým odtokem; Popis sestavy: Uliční; PRÁVNÍ OZNÁMENÍ: "Copyright (©), autorská a jiná práva spojená s duševním vlastnictvím, jsou výhradním vlastnictvím společnosti HL Hutterer & Lechner GmbH. Úpravy nejsou dovoleny. Rodina je opatřená vodoznakem."; STAVEBNÍ VÝŠKA: 213 mm; TŘÍDA ZATÍŽENÍ: B - 12,5 t (außen); URL: http://www.hutterer-lechner.com/cs/products/catalog/roof-drains/HL606.1/1.aspx; VTOKOVÁ MŘÍŽKA: Gusseisen 226 x 226 mm; Výrobce: HL Hutterer & Lechner GmbH
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Uliční vpusť
Classification: VP04 Uniformat (Uniformat); Group: SW_Deště přípojka 3
Mechanické – tok - PRŮTOK: 0 m3/s
Text - CCI Funkční systém: G; CCI Komponenta: XKE; CCI Technický systém: JD
Vazby - Podlaží: 1.NP_SO-101,102; Hostitel: Podlaží : 1.NP_SO-101,102; Odsazení od hostitele: -4100 mm; Výška od podlaží: -4100 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární; Název systému: SW_Deště přípojka 3; Typ systému: SW_Deště přípojka
Kóty - Objem: 0.00355321 m3; Stavební výška 1: 0 mm; Stavební výška 2: 0 mm
Identifikační data - Kód prvku: VP04.01.0001; Označení: 0001
Jiné - Páteřní trasa: yes; A: 15 mm; B: 100 mm; C: 0 mm; D: 185 mm; G: 180 deg; Id typu: 12857385; IH: 0 mm; Rodina: Uliční vpusť; Rodina a typ: Uliční vpusť: DN110; Typ: DN110

# IfcGroup: Modelová skupina:Skupina 1 (3)
Vazby - Odsazení počátku podlaží: 30941.8 mm; Referenční podlaží: 1.NP_SO-101,102
Jiné - Id typu: 12778319; Kategorie: Skupiny modelů; Rodina: Modelová skupina; Rodina a typ: Modelová skupina: Skupina 1; Typ: Skupina 1
Identifikační data(Type) - Název typu: Skupina 1
Jiné(Type) - Kategorie: Skupiny modelů; Název rodiny: Modelová skupina
Name (Modelová skupina:Skupina 1:...)
12778681
12778788
12871781

# IfcPipeFitting: M_Koleno, obecné:Standardní (9)
In: 1.NP_SO-101,102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: K; Kód sestavy: TT01; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 02; Popis: Koleno; Popis sestavy: Koleno
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Koleno, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Podlaží: 1.NP_SO-101,102
Mechanické - Klasifikace systému: Sanitární
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3326550; Rodina: M_Koleno, obecné; Rodina a typ: M_Koleno, obecné: Standardní
Name (M_Koleno, obecné:Standardní:...) | Celková velikost | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Páteřní trasa | Tlaková ztráta (Pa)
12779091 | ø250 mm-ø250 mm | -3834.57 | Stávající stav | SW_Splašky řad | SW_Splašky řad 1 | 125 | 250 | 0.00574837 | 58.6585 | 46.99 | ø250-ø250 | 44.7185 | 257.175 | TT01.02.0003 | 0003 | 134.938 | 128.588
12779271 | ø400 mm-ø400 mm | -2550.56 | Stávající stav | SW_Splašky řad | SW_Splašky řad 1 | 200 | 400 | 0.0273786 | 113.194 | 56.3929 | ø400-ø400 | 87.8318 | 409.575 | TT01.02.0008 | 0008 | 211.138 | 204.788
12780937 | ø250 mm-ø250 mm | -4628.95 | Fáze 1 | SW_Splašky přípojka | SW_Splašky přípojka 2 | 125 | 250 | 0.0108539 | 131.965 | 88.7237 | ø250-ø250 | 100.604 | 257.175 | TT01.02.0014 | 0014 | 134.938 | 128.588 | yes
12865028 | ø300 mm-ø300 mm | -5057.43 | Stávající stav | SW_Splašky řad | SW_Splašky řad 1 | 150 | 300 | 0.0187613 | 160.337 | 90 | ø300-ø300 | 123.19 | 307.975 | TT01.02.0031 | 0031 | 160.338 | 153.988 |  | 0
12865161 | ø150 mm-ø150 mm | -4942.16 | Fáze 1 | SW_Deště přípojka | SW_Deště přípojka 3 | 75 | 150 | 0.00248028 | 82.4716 | 88.8542 | ø150-ø150 | 60.9978 | 155.575 | TT01.02.0033 | 0033 | 84.1375 | 77.7875 |  | 0
12865172 | ø125 mm-ø125 mm | -4530 | Fáze 1 | SW_Deště přípojka | SW_Deště přípojka 3 | 62.5 | 125 | 0.00150291 | 72.1554 | 90.5729 | ø125-ø125 | 52.5933 | 130.175 | TT01.02.0034 | 0034 | 71.4375 | 65.0875 | yes | 0
12865176 | ø150 mm-ø150 mm | -4518.71 | Fáze 1 | SW_Deště přípojka | SW_Deště přípojka 3 | 75 | 150 | 0.0024965 | 83.3123 | 89.4353 | ø150-ø150 | 61.6197 | 155.575 | TT01.02.0035 | 0035 | 84.1375 | 77.7875 | yes | 0
12870865 | ø150 mm-ø150 mm | -3519.73 | Fáze 2 | SW_Deště přípojka | SW_Deště přípojka 1 | 75 | 150 | 0.00125612 | 34.8509 | 45 | ø150-ø150 | 25.7765 | 155.575 | TT01.02.0039 | 0039 | 84.1375 | 77.7875 | yes | 0
12870870 | ø150 mm-ø150 mm | -3772.53 | Fáze 2 | SW_Deště přípojka | SW_Deště přípojka 1 | 75 | 150 | 0.00124014 | 34.3594 | 44.4275 | ø150-ø150 | 25.413 | 155.575 | TT01.02.0040 | 0040 | 84.1375 | 77.7875 | yes | 0

# IfcPipeFitting: M_Přechod, obecný:Standardní (4)
In: 1.NP_SO-101,102
Type - Material: 0-128-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT03; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: Redukce; Popis sestavy: Redukce
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT03 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Podlaží: 1.NP_SO-101,102
Mechanické - Typ systému: SW_Deště přípojka; Klasifikace systému: Sanitární
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm; Viditelnost 1: no; Výškové odsazení: 3048 mm; Viditelnost 2: no; Viditelnost 3: yes
Name (M_Přechod, obecný:Standardní:...) | Celková velikost | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – šířka = Odskok – výška | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = Minimální velikost (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = Maximální velikost (mm) = DN tvarovky 2 (sdílený) (mm) | Objem (m3) | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) = Max. vnější průměr tvarovky 12 (mm) | Kód prvku | Označení | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
12859631 | ø125 mm-ø110 mm | -4385 | Fáze 1 | SW_Deště přípojka 3 | 32.5438 | 55 | 62.5 | 110 | 125 | 0.000378906 | 0.0222459 | ø125-ø110 | 45.27 | 52.07 | 113.175 | 130.175 | TT03.03.0030 | 0030 | 65.0875 | 56.5875 | Jiné - Páteřní trasa: yes
12865726 | ø150 mm-ø125 mm | -4529.28 | Fáze 1 | SW_Deště přípojka 3 | 38.8938 | 62.5 | 75 | 125 | 150 | 0.000625098 | 0.030951 | ø150-ø125 | 52.07 | 62.23 | 130.175 | 155.575 | TT03.03.0036 | 0036 | 77.7875 | 65.0875 | Jiné - Páteřní trasa: yes
12865740 | ø300 mm-ø150 mm | -4943.8 | Fáze 1 | SW_Deště přípojka 3 | 76.9938 | 75 | 150 | 150 | 300 | 0.0033652 | 0.0977084 | ø300-ø150 | 62.23 | 123.19 | 155.575 | 307.975 | TT03.03.0037 | 0037 | 153.988 | 77.7875
12870504 | ø150 mm-ø125 mm | -985.142 | Fáze 2 | SW_Deště přípojka 1 | 38.8938 | 62.5 | 75 | 125 | 150 | 0.000625098 | 0.030951 | ø150-ø125 | 52.07 | 62.23 | 130.175 | 155.575 | TT03.03.0038 | 0038 | 77.7875 | 65.0875

# IfcPipeFitting: M_Přechod, obecný:Standardní (16)
In: 1.NP_SO-101,102
Type - Material: 128-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT03; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: Redukce; Popis sestavy: Redukce
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT03 Uniformat (Uniformat); Group: SW_Splašky řad 1
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Podlaží: 1.NP_SO-101,102
Fázování - Fáze vytvoření: Stávající stav
Mechanické - Typ systému: SW_Splašky řad; Klasifikace systému: Sanitární; Název systému: SW_Splašky řad 1
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Viditelnost 1: no; Viditelnost 2: yes; Viditelnost 3: no
Name (M_Přechod, obecný:Standardní:...) | Celková velikost | Výška od podlaží (mm) | Délka (mm) | Jmenovitý poloměr 1 (mm) | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = Maximální velikost (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = Minimální velikost (mm) = DN tvarovky 2 (sdílený) (mm) | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) = Max. vnější průměr tvarovky 12 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Šířkové odsazení (mm) | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm) | Výškové odsazení (mm)
12779557 | ø400 mm-ø250 mm | -4000.15 | 102.394 | 200 | 125 | 400 | 250 | 0.00909295 | 200 | 200 | 0.187288 | ø400-ø250 | 163.83 | 102.87 | 409.575 | 257.175 | TT03.03.0009 | 0009 | 3048 | 128.588 | 204.788 | 3048
12779559 | ø400 mm-ø250 mm | -3655.36 | 102.394 | 200 | 125 | 400 | 250 | 0.00909295 | 200 | 200 | 0.187288 | ø400-ø250 | 163.83 | 102.87 | 409.575 | 257.175 | TT03.03.0010 | 0010 | 3048 | 128.588 | 204.788 | 3048
12779561 | ø400 mm-ø250 mm | -3179.43 | 102.394 | 200 | 125 | 400 | 250 | 0.00909295 | 200 | 200 | 0.187288 | ø400-ø250 | 163.83 | 102.87 | 409.575 | 257.175 | TT03.03.0011 | 0011 | 3048 | 128.588 | 204.788 | 3048
12779563 | ø400 mm-ø250 mm | -2808.75 | 102.394 | 200 | 125 | 400 | 250 | 0.00909295 | 200 | 200 | 0.187288 | ø400-ø250 | 163.83 | 102.87 | 409.575 | 257.175 | TT03.03.0012 | 0012 | 3048 | 128.588 | 204.788 | 3048
12783911 | ø500 mm-ø300 mm | -6612.59 | 127.794 | 250 | 150 | 500 | 300 | 0.0171819 | 250 | 250 | 0.287325 | ø500-ø300 | 204.47 | 123.19 | 511.175 | 307.975 | TT03.03.0016 | 0016 | 3048 | 153.988 | 255.588 | 3048 | Mechanické – tok - Tlaková ztráta: 0 Pa
12784007 | ø500 mm-ø300 mm | -4844.71 | 127.794 | 250 | 150 | 500 | 300 | 0.0171819 | 252.46 | 249.951 | 0.287191 | ø500-ø300 | 204.47 | 123.19 | 511.175 | 307.975 | TT03.03.0017 | 0017 | 3050.46 | 153.988 | 255.588 | 3047.95
12784069 | ø500 mm-ø300 mm | -4844.71 | 127.794 | 250 | 150 | 500 | 300 | 0.0171819 | 250 | 250 | 0.287325 | ø500-ø300 | 204.47 | 123.19 | 511.175 | 307.975 | TT03.03.0018 | 0018 | 3048 | 153.988 | 255.588 | 3048
12784071 | ø400 mm-ø300 mm | -4008.84 | 102.394 | 200 | 150 | 400 | 300 | 0.0104203 | 199.95 | 199.975 | 0.203878 | ø400-ø300 | 163.83 | 123.19 | 409.575 | 307.975 | TT03.03.0019 | 0019 | 3047.95 | 153.988 | 204.788 | 3047.98
12784073 | ø400 mm-ø300 mm | -4000.15 | 102.394 | 200 | 150 | 400 | 300 | 0.0104203 | 200.025 | 199.95 | 0.203873 | ø400-ø300 | 163.83 | 123.19 | 409.575 | 307.975 | TT03.03.0020 | 0020 | 3048.02 | 153.988 | 204.788 | 3047.95
12784075 | ø400 mm-ø300 mm | -3664.06 | 102.394 | 200 | 150 | 400 | 300 | 0.0104203 | 200 | 200 | 0.203879 | ø400-ø300 | 163.83 | 123.19 | 409.575 | 307.975 | TT03.03.0021 | 0021 | 3048 | 153.988 | 204.788 | 3048
12784077 | ø400 mm-ø300 mm | -3655.36 | 102.394 | 200 | 150 | 400 | 300 | 0.0104203 | 200 | 200 | 0.203879 | ø400-ø300 | 163.83 | 123.19 | 409.575 | 307.975 | TT03.03.0022 | 0022 | 3048 | 153.988 | 204.788 | 3048
12784079 | ø400 mm-ø300 mm | -3188.12 | 102.394 | 200 | 150 | 400 | 300 | 0.0104203 | 200 | 200 | 0.203879 | ø400-ø300 | 163.83 | 123.19 | 409.575 | 307.975 | TT03.03.0023 | 0023 | 3048 | 153.988 | 204.788 | 3048
12784081 | ø400 mm-ø300 mm | -3179.43 | 102.394 | 200 | 150 | 400 | 300 | 0.0104203 | 200 | 200 | 0.203879 | ø400-ø300 | 163.83 | 123.19 | 409.575 | 307.975 | TT03.03.0024 | 0024 | 3048 | 153.988 | 204.788 | 3048
12784083 | ø400 mm-ø300 mm | -2817.45 | 102.394 | 200 | 150 | 400 | 300 | 0.0104203 | 200 | 200 | 0.203879 | ø400-ø300 | 163.83 | 123.19 | 409.575 | 307.975 | TT03.03.0025 | 0025 | 3048 | 153.988 | 204.788 | 3048
12784085 | ø400 mm-ø300 mm | -2808.75 | 102.394 | 200 | 150 | 400 | 300 | 0.0104203 | 200 | 200 | 0.203879 | ø400-ø300 | 163.83 | 123.19 | 409.575 | 307.975 | TT03.03.0026 | 0026 | 3048 | 153.988 | 204.788 | 3048
12784087 | ø400 mm-ø300 mm | -2552.82 | 102.394 | 200 | 150 | 400 | 300 | 0.0104203 | 200 | 200 | 0.203879 | ø400-ø300 | 163.83 | 123.19 | 409.575 | 307.975 | TT03.03.0027 | 0027 | 3048 | 153.988 | 204.788 | 3048

# IfcPipeFitting: M_Spoj T, obecný:Standardní (7)
In: 1.NP_SO-101,102
Type - Material: 128-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT02; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 01; Popis: T kus; Popis sestavy: Odbočka
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT02 Uniformat (Uniformat); Group: SW_Splašky řad 1
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Podlaží: 1.NP_SO-101,102
Fázování - Fáze vytvoření: Stávající stav
Mechanické - Typ systému: SW_Splašky řad; Klasifikace systému: Sanitární; Název systému: SW_Splašky řad 1
Grafika - Použít měřítko poznámky: no
Jiné - Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní; Typ: Standardní
Name (M_Spoj T, obecný:Standardní:...) | Celková velikost | Výška od podlaží (mm) | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Štítek, od středu ke konci (mm) | Úhel 1 (deg) = Úhel tvarovky 1 (sdílený) (deg) | Vnější poloměr tvarovky (mm)
12776020 | ø500 mm-ø500 mm-ø500 mm | -4850.08 | 250 | 500 | 0.120651 | 268.288 | 89.3735 | ø500-ø500-ø500 | 204.47 | 511.175 | TT02.01.0001 | 0001 | 268.288 | 89.3735 | 255.588
12779072 | ø400 mm-ø400 mm-ø400 mm | -4004.5 | 200 | 400 | 0.0630556 | 217.488 | 89.3825 | ø400-ø400-ø400 | 163.83 | 409.575 | TT02.01.0002 | 0002 | 217.488 | 89.3825 | 204.788
12779113 | ø250 mm-ø250 mm-ø250 mm | -3872.91 | 125 | 250 | 0.0383417 | 141.288 | 46.99 | ø250-ø250-ø250 | 102.87 | 257.175 | TT02.01.0004 | 0004 | 295.801 | 46.99 | 128.588
12779156 | ø400 mm-ø400 mm-ø400 mm | -3659.71 | 200 | 400 | 0.063057 | 217.488 | 89.9771 | ø400-ø400-ø400 | 163.83 | 409.575 | TT02.01.0005 | 0005 | 217.488 | 89.9771 | 204.788
12779201 | ø400 mm-ø400 mm-ø400 mm | -3183.78 | 200 | 400 | 0.063057 | 217.488 | 89.9771 | ø400-ø400-ø400 | 163.83 | 409.575 | TT02.01.0006 | 0006 | 217.488 | 89.9771 | 204.788
12779241 | ø400 mm-ø400 mm-ø400 mm | -2813.1 | 200 | 400 | 0.063057 | 217.488 | 89.9771 | ø400-ø400-ø400 | 163.83 | 409.575 | TT02.01.0007 | 0007 | 217.488 | 89.9771 | 204.788
12781091 | ø500 mm-ø500 mm-ø500 mm | -6617.96 | 250 | 500 | 0.12065 | 268.288 | 90.2276 | ø500-ø500-ø500 | 204.47 | 511.175 | TT02.01.0015 | 0015 | 268.288 | 89.7724 | 255.588

# IfcPipeFitting: M_Spojka, obecná:Standardní (2)
In: 1.NP_SO-101,102
Type - Material: 128-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: S; Kód sestavy: TT04; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 04; Popis: Spojení; Popis sestavy: Spojka
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spojka, obecná; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT04 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Podlaží: 1.NP_SO-101,102
Mechanické - Klasifikace systému: Sanitární
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 1484366; Rodina: M_Spojka, obecná; Rodina a typ: M_Spojka, obecná: Standardní
Name (M_Spojka, obecná:Standardní:...) | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Název systému = Group | Délka (mm) = Vnější poloměr tvarovky (mm) | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení
12833364 | 128.588 | 0.0519385 | 0.103891 | ø250 mm-ø250 mm | -4953.75 | Fáze 1 | SW_Splašky přípojka | SW_Splašky přípojka 2 | 128.588 | 125 | 250 | 0.00667922 | ø250-ø250 | 102.87 | 257.175 | TT04.04.0029 | 0029 | Jiné - Páteřní trasa: yes
12865055 | 153.987 | 0.074484 | 0.148988 | ø300 mm-ø300 mm | -5067.81 | Stávající stav | SW_Splašky řad | SW_Splašky řad 1 | 153.988 | 150 | 300 | 0.0114706 | ø300-ø300 | 123.19 | 307.975 | TT04.04.0032 | 0032 | Mechanické – tok - Tlaková ztráta: 0 Pa

# IfcPipeSegment: Typy trubek:Beton, Typy trubek:Beton:12781092
In: 1.NP_SO-101,102
Type - Material: 128-0-0
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - Cena: 0; ID kategorie: TR; Kód sestavy: TR06; Model: B; Název typu: Beton; Označení typu: 04; Popis: BET; Popis sestavy: Polyvinyl chlorid (PVC); Výrobce: Ostendorf - OSMA
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR06 Uniformat (Uniformat); Group: SW_Splašky řad 1
Qto_PipeSegmentBaseQuantities - Length: 87876.3 mm; GrossCrossSectionArea: 0.196306 m2; NetCrossSectionArea: 0.196306 m2; OuterSurfaceArea: 138.036 m2
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø500 mm
Mechanické – tok - Instalační jednotky: 0; Relativní drsnost: 0.000262936
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Horizontální zarovnání: Na střed; Referenční podlaží: 1.NP_SO-101,102; Vertikální zarovnání: Střed; Horní výška: -4605.49 mm; Koncová střední výška: -6612.59 mm; Počáteční střední výška: -4855.44 mm; Sklon: 1.99997; Spodní výška: -6862.54 mm; Střední výška: -4855.44 mm
Fázování - Fáze vytvoření: Stávající stav
Mechanické - Typ systému: SW_Splašky řad; Materiál: PVC–U_KG SYSTEM; Úsek potrubí: PVC–U_KG SYSTEM - SN4; Výkaz/typ: SN4; Drsnost: 0.125 mm; Klasifikace systému: Sanitární; Název systému: SW_Splašky řad 1; Obrátit výšku: -6850.24 mm; Plocha: 138.036 m2; Popis úseku: PVC–KGEM SN4; Průměr: 500 mm; Řez: 6; Typ přípoje: Obecné
Kóty - Délka: 87876.3 mm; Velikost: ø500; Vnější průměr: 500 mm; Vnitřní průměr: 475.4 mm
Identifikační data - Kód prvku: TR06.04.0019; Komentáře: STÁVAJÍCÍ KANALIZAČNÍ POTRUBÍ; Označení: 0019
Jiné - Rodina: Typy trubek; Id typu: 12783927; Rodina a typ: Typy trubek: Beton; Typ: Beton

# IfcPipeSegment: Typy trubek:Beton2 (7)
In: 1.NP_SO-101,102
Type - Material: 128-0-0
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - Cena: 0; ID kategorie: TR; Kód sestavy: TR16; Model: B; Název typu: Beton2; Označení typu: 01; Popis: BET; Popis sestavy: Kompozitní materiál; Výrobce: Steinzeug-Keramo
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR16 Uniformat (Uniformat)
Qto_PipeSegmentBaseQuantities - GrossCrossSectionArea: 0.0706752 m2; NetCrossSectionArea: 0.0706752 m2
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø300 mm
Mechanické – tok - Instalační jednotky: 0; Relativní drsnost: 0.00258
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Horizontální zarovnání: Na střed; Referenční podlaží: 1.NP_SO-101,102; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Stávající stav
Mechanické - Drsnost: 0.774 mm; Materiál: Keramika; Popis úseku: KT; Průměr: 300 mm; Typ přípoje: Obecné; Úsek potrubí: Keramika - Kamenina, spojovací systém C, tř. pevn. 160, uvnitř glazované; Výkaz/typ: Kamenina, spojovací systém C, tř. pevn. 160, uvnitř glazované
Kóty - Velikost: ø300; Vnější průměr: 300 mm; Vnitřní průměr: 300 mm
Jiné - Id typu: 12784010; Rodina: Typy trubek; Rodina a typ: Typy trubek: Beton2; Typ: Beton2
Name (Typy trubek:Beton2:...) | Length (mm) = Délka (mm) | OuterSurfaceArea (m2) = Plocha (m2) | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Sklon | Spodní výška (mm) = Obrátit výšku (mm) | Klasifikace systému | Název systému = Group | Řez | Typ systému | Kód prvku | Komentáře | Označení
12765154 | 19639 | 18.5093 | -4299.49 | -4449.46 | -4842.16 | 2 | -4992.13 | Sanitární | SW_Splašky řad 1 | 27 | SW_Splašky řad | TR16.01.0001 | STÁVAJÍCÍ KANALIZAČNÍ POTRUBÍ | 0001
12765635 | 12594.3 | 11.8699 | -2404.9 | -2554.87 | -2806.7 | 1.99999 | -2956.67 | Sanitární | SW_Splašky řad 1 | 32 | SW_Splašky řad | TR16.01.0002 | STAVAJÍCÍ KANALIZAČNÍ POTRUBÍ | 0002
12779073 | 41569.4 | 39.1782 | -3860.97 | -4010.94 | -4842.16 | 1.99999 | -4992.13 | Sanitární | SW_Splašky řad 1 | 41 | SW_Splašky řad | TR16.01.0007 | STÁVAJÍCÍ KANALIZAČNÍ POTRUBÍ | 0007
12779202 | 23161.7 | 21.8294 | -3040.2 | -3190.17 | -3653.31 | 1.99999 | -3803.28 | Sanitární | SW_Splašky řad 1 | 37 | SW_Splašky řad | TR16.01.0013 | STAVAJÍCÍ KANALIZAČNÍ POTRUBÍ | 0013
12779242 | 17897.8 | 16.8683 | -2669.53 | -2819.5 | -3177.38 | 1.99999 | -3327.35 | Sanitární | SW_Splašky řad 1 | 35 | SW_Splašky řad | TR16.01.0015 | STÁVAJÍCÍ KANALIZAČNÍ POTRUBÍ | 0015
12779260 | 8986.03 | 8.46913 | -2218.64 | -2368.61 | -2548.3 | 2 | -2698.27 | Nedefinovaný |  | 19 |  | TR16.01.0016 | RUŠENÍ STÁVAJÍCÍ KANALIZAČNÍ PŘÍPOJKY (ODBOČKA ZASLEPENA, POTRUBÍ ZAFOUKÁNO POPÍLKOBETONEM A KONCE ZASLEPENY) - ŘEŠENO V RÁMCI DBP | 0016 | Mechanické – tok - Reynoldsovo číslo: 0; Stav průtoku: Laminární; Doplňkový průtok: 0 m3/s; Průtok: 0 m3/s; Rychlost: 0 m/s; Fázování - Bouráno ve FÁZI 2: yes; Fáze demolice: Fáze 2
12849700 | 16605.6 | 15.6504 | -3516.13 | -3666.1 | -3998.15 | 1.99999 | -4148.12 | Sanitární | SW_Splašky řad 1 | 42 | SW_Splašky řad | TR16.01.0023 | STÁVAJÍCÍ KANALIZAČNÍ POTRUBÍ | 0023

# IfcPipeSegment: Typy trubek:Kamenina (10)
In: 1.NP_SO-101,102
Type - Material: 128-0-0
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - Cena: 0; ID kategorie: TR; Kód sestavy: TR15; Název typu: Kamenina; Označení typu: 03; Popis: Kamenina; Popis sestavy: Kamenina
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR15 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Instalační jednotky: 0
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Horizontální zarovnání: Na střed; Referenční podlaží: 1.NP_SO-101,102; Vertikální zarovnání: Střed
Mechanické - Materiál: Keramika; Úsek potrubí: Keramika - Kamenina, spojovací systém C, tř. pevn. 160, uvnitř glazované; Výkaz/typ: Kamenina, spojovací systém C, tř. pevn. 160, uvnitř glazované; Drsnost: 0.774 mm; Popis úseku: KT; Typ přípoje: Obecné
Jiné - Rodina: Typy trubek; Id typu: 12865666; Rodina a typ: Typy trubek: Kamenina; Typ: Kamenina
Name (Typy trubek:Kamenina:...) | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Relativní drsnost | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Spodní výška (mm) | Střední výška (mm) | Fáze vytvoření | Klasifikace systému | Název systému = Group | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Typ systému | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa
12776254 | 8876.82 | 0.0702048 | 8.33831 | ø250 mm | 0.00312097 | 2 | -4299.34 | -4626.31 | -4448.81 | -4775.78 | -4626.31 | Fáze 1 | Sanitární | SW_Splašky přípojka 2 | -4750.28 | 6.97183 | 250 | 3 | SW_Splašky přípojka | ø250 | 299 | 248 | TR15.03.0004 | 0004 | yes | Identifikační data - Komentáře: NOVÁ SPLAŠKOVÁ KANALIZAČNÍ PŘÍPOJKA - S1
12777797 | 8260 | 0.0706752 | 7.78487 | ø300 mm | 0.00258 | 2.0002 | -5344.47 | -5659.62 | -5494.44 | -5809.59 | -5494.44 | Fáze 1 | Sanitární | SW_Splašky přípojka 3 | -5809.59 | 7.78487 | 300 | 2 | SW_Splašky přípojka | ø300 | 300 | 300 | TR15.03.0005 | 0005 | yes | Identifikační data - Komentáře: NOVÁ SPLAŠKOVÁ KANALIZAČNÍ PŘÍPOJKA - S2
12780927 | 434.937 | 0.0702048 | 0.408552 | ø250 mm | 0.00312097 | 100 | -4893.5 | -5306.76 | -4999.21 | -5412.47 | -4999.21 | Fáze 1 | Sanitární | SW_Splašky přípojka 2 | -5394.44 | 0.341598 | 250 | 3 | SW_Splašky přípojka | ø250 | 299 | 248 | TR15.03.0018 | 0018 | yes
12833362 | 263.083 | 0.0702048 | 0.247123 | ø250 mm | 0.00312097 | 100 | -4616.55 | -4908.29 | -4722.26 | -5014 | -4722.26 | Fáze 1 | Sanitární | SW_Splašky přípojka 2 | -4995.97 | 0.206625 | 250 | 3 | SW_Splašky přípojka | ø250 | 299 | 248 | TR15.03.0022 | 0022 | yes
12858366 | 944.885 | 0.0176688 | 0.445266 | ø150 mm | 0.00516 | 0.989416 | -4444.54 | -4519.54 | -4528.89 | -4603.89 | -4528.89 | Fáze 1 | Sanitární | SW_Deště přípojka 3 | -4603.89 | 0.445266 | 150 | 3 | SW_Deště přípojka | ø150 | 150 | 150 | TR15.03.0024 | 0024 | yes | Identifikační data - Komentáře: NOVÁ DEŠŤOVÁ KANALIZAČNÍ PŘÍPOJKA - D2
12865159 | 257.747 | 0.0176688 | 0.12146 | ø150 mm | 0.00516 | 5035.82 | -4600.51 | -4602 | -4859.7 | -4861.19 | -4859.7 | Fáze 1 | Sanitární | SW_Deště přípojka 3 | -4861.19 | 0.12146 | 150 | 3 | SW_Deště přípojka | ø150 | 150 | 150 | TR15.03.0029 | 0029 | yes
12866303 | 11300 | 0.0702048 | 10.6145 | ø250 mm | 0.00312097 | 2 | -4999.34 | -5374.76 | -5148.81 | -5524.23 | -5148.81 | Stávající stav | Nedefinovaný |  | -5498.74 | 8.875 | 250 | 1 |  | ø250 | 299 | 248 | TR15.03.0030 | 0030 | Identifikační data - Komentáře: RUŠENÍ STÁVAJÍCÍ KANALIZAČNÍ PŘÍPOJKY (ODBOČKA ZASLEPENA, ČÁST POTRUBÍ OD STAVEBNÍ JÁMY K OBJEKTU VYJMUTÁ, ZBYTEK ZAFOUKÁNO POPÍLKOBETONEM A KONCE ZASLEPENY) - ŘEŠENO V RÁMCI DBP; Mechanické – tok - Reynoldsovo číslo: 0; Stav průtoku: Laminární; Doplňkový průtok: 0 m3/s; Průtok: 0 m3/s; Rychlost: 0 m/s; Fázování - Fáze demolice: Fáze 1
12870494 | 2460.84 | 0.0176688 | 1.15965 | ø150 mm | 0.00516 |  | -1024.04 | -3484.88 | -1024.04 | -3484.88 | -1024.04 | Fáze 2 | Sanitární | SW_Deště přípojka 1 | -3484.88 | 1.15965 | 150 | 2 | SW_Deště přípojka | ø150 | 150 | 150 | TR15.03.0031 | 0031 | yes
12870681 | 1160.64 | 0.0176688 | 0.546939 | ø150 mm | 0.00516 | 0.999992 | -3697.88 | -3784.48 | -3772.87 | -3859.47 | -3772.87 | Fáze 2 | Sanitární | SW_Deště přípojka 1 | -3859.47 | 0.546939 | 150 | 2 | SW_Deště přípojka | ø150 | 150 | 150 | TR15.03.0032 | 0032 | yes | Identifikační data - Komentáře: NOVÁ DEŠŤOVÁ KANALIZAČNÍ PŘÍPOJKA - D3
12870683 | 288.3 | 0.0176688 | 0.135858 | ø150 mm | 0.00516 | 100 | -3491.34 | -3748.23 | -3544.37 | -3801.27 | -3544.37 | Fáze 2 | Sanitární | SW_Deště přípojka 1 | -3801.27 | 0.135858 | 150 | 2 | SW_Deště přípojka | ø150 | 150 | 150 | TR15.03.0033 | 0033 | yes

# IfcPipeSegment: Typy trubek:Kamenina_hrdlové trouby (2)
In: 1.NP_SO-101,102
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - Cena: 0; ID kategorie: TR; Kód sestavy: TR15; Model: KT; Název typu: Kamenina_hrdlové trouby; Označení typu: 05; Popis: KER; Popis sestavy: Kamenina; Výrobce: Steinzeug-Keramo
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR15 Uniformat (Uniformat)
Qto_PipeSegmentBaseQuantities - GrossCrossSectionArea: 0.0706752 m2; NetCrossSectionArea: 0.0706752 m2
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø300 mm
Mechanické – tok - Instalační jednotky: 0; Relativní drsnost: 0.00258
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Horizontální zarovnání: Na střed; Referenční podlaží: 1.NP_SO-101,102; Vertikální zarovnání: Střed; Sklon: 2
Fázování - Fáze vytvoření: Stávající stav
Mechanické - Materiál: Keramika; Úsek potrubí: Keramika - Kamenina, spojovací systém C, tř. pevn. 160, uvnitř glazované; Výkaz/typ: Kamenina, spojovací systém C, tř. pevn. 160, uvnitř glazované; Drsnost: 0.774 mm; Popis úseku: KT; Průměr: 300 mm; Typ přípoje: Obecné
Kóty - Velikost: ø300; Vnější průměr: 300 mm; Vnitřní průměr: 300 mm
Jiné - Rodina: Typy trubek; Id typu: 9442185; Rodina a typ: Typy trubek: Kamenina_hrdlové trouby; Typ: Kamenina_hrdlové trouby
Name (Typy trubek:Kamenina_hrdlové trouby:...) | Length (mm) = Délka (mm) | OuterSurfaceArea (m2) = Plocha (m2) | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) = Obrátit výšku (mm) | Klasifikace systému | Řez | Kód prvku | Komentáře | Označení
12781096 | 15600 | 14.7027 | -4484.87 | -4634.84 | -4946.78 | -5096.75 | Nedefinovaný | 29 | TR15.05.0020 | ZRUŠENÍ STÁVAJÍCÍ KANALIZAČNÍ PŘÍPOJKY (ODBOČKA ZASLEPENA, ČÁST POTRUBÍ OD STAVEBNÍ JÁMY K OBJEKTU VYJMUTÁ, ZBYTEK ZAFOUKÁNO POPÍLKOBETONEM A KONCE ZASLEPENY) - ŘEŠENO V RÁMCI DBP | 0020 | Mechanické – tok - Reynoldsovo číslo: 0; Stav průtoku: Laminární; Doplňkový průtok: 0 m3/s; Průtok: 0 m3/s; Rychlost: 0 m/s; Fázování - Fáze demolice: Fáze 2
12858807 | 77049.6 | 72.6176 | -4919.38 | -5069.35 | -6610.04 | -6760.01 | Sanitární | 45 | TR15.05.0026 | STÁVAJÍCÍ KANALIZAČNÍ POTRUBÍ | 0026 | Material: 128-0-0; Group: SW_Splašky řad 1; Mechanické - Typ systému: SW_Splašky řad; Název systému: SW_Splašky řad 1

# IfcPipeSegment: Typy trubek:PVC-U_KG systém (11)
In: 1.NP_SO-101,102
Type - Material: 128-0-0
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - Cena: 0; ID kategorie: TR; Kód sestavy: TR06; Model: KT; Název typu: PVC-U_KG systém; Označení typu: 02; Popis: PVC-U; Popis sestavy: Polyvinyl chlorid (PVC); Výrobce: Ostendorf - OSMA
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR06 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Instalační jednotky: 0
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Horizontální zarovnání: Na střed; Referenční podlaží: 1.NP_SO-101,102; Vertikální zarovnání: Střed
Mechanické - Drsnost: 0.125 mm; Materiál: PVC–U_KG SYSTEM; Popis úseku: PVC–KGEM SN4; Typ přípoje: Obecné; Úsek potrubí: PVC–U_KG SYSTEM - SN4; Výkaz/typ: SN4
Jiné - Rodina: Typy trubek; Id typu: 9442186; Rodina a typ: Typy trubek: PVC-U_KG systém; Typ: PVC-U_KG systém
Name (Typy trubek:PVC-U_KG systém:...) | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Sklon | Spodní výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Obrátit výšku (mm) | Průměr (mm) = Vnější průměr (mm) | Řez | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Group
12766152 | 4213.07 | 0.196306 | 6.61787 | ø500 mm | 0.000262936 | -6373.37 | -6707.56 | -6623.32 | 1.99997 | -6957.51 | Stávající stav | SW_Splašky řad | Sanitární | SW_Splašky řad 1 | -6945.22 | 500 | 28 | ø500 | 475.4 | TR06.02.0003 | 0003 | SW_Splašky řad 1
12779062 | 1562.57 | 0.04908 | 1.22724 | ø250 mm | 0.000526094 | -3710.77 | -3835.75 | -3866.99 | 2 | -3991.97 | Stávající stav | SW_Splašky řad | Sanitární | SW_Splašky řad 1 | -3985.77 | 250 | 13 | ø250 | 237.6 | TR06.02.0006 | 0006 | SW_Splašky řad 1
12779079 | 1337.43 | 0.04908 | 1.05041 | ø250 mm | 0.000526094 | -3681.68 | -3806.66 | -3833.4 | 2 | -3958.38 | Stávající stav | SW_Splašky řad | Sanitární | SW_Splašky řad 1 | -3952.18 | 250 | 13 | ø250 | 237.6 | TR06.02.0008 | 0008 | SW_Splašky řad 1
12779103 | 1200.3 | 0.04908 | 0.942717 | ø250 mm | 0.000526094 | -3718.02 | -3842.99 | -3866.99 | 2 | -3991.97 | Stávající stav | SW_Splašky řad | Sanitární | SW_Splašky řad 1 | -3985.77 | 250 | 14 | ø250 | 237.6 | TR06.02.0009 | 0009 | SW_Splašky řad 1
12779114 | 5965.03 | 0.04908 | 4.68492 | ø250 mm | 0.000526094 | -3753.85 | -3878.82 | -3998.1 | 2 | -4123.07 | Stávající stav | SW_Splašky řad | Sanitární | SW_Splašky řad 1 | -4116.88 | 250 | 12 | ø250 | 237.6 | TR06.02.0010 | 0010 | SW_Splašky řad 1
12779146 | 9178 | 0.04908 | 7.20838 | ø250 mm | 0.000526094 | -3344.81 | -3469.79 | -3653.31 | 2 | -3778.29 | Stávající stav |  | Nedefinovaný |  | -3772.09 | 250 | 16 | ø250 | 237.6 | TR06.02.0011 | 0011 | Mechanické – tok - Doplňkový průtok: 0 m3/s; Průtok: 0 m3/s; Reynoldsovo číslo: 0; Rychlost: 0 m/s; Stav průtoku: Laminární; Fázování - Bouráno ve FÁZI 2: yes; Fáze demolice: Fáze 2; Identifikační data - Komentáře: RUŠENÍ STÁVAJÍCÍ KANALIZAČNÍ PŘÍPOJKY (ODBOČKA ZASLEPENA, ČÁST POTRUBÍ OD STAVEBNÍ JÁMY K OBJEKTU VYJMUTÁ, ZBYTEK ZAFOUKÁNO POPÍLKOBETONEM A KONCE ZASLEPENY) - ŘEŠENO V RÁMCI DBP
12779191 | 9178 | 0.04908 | 7.20838 | ø250 mm | 0.000526094 | -2868.88 | -2993.86 | -3177.38 | 2 | -3302.35 | Stávající stav |  | Nedefinovaný |  | -3296.16 | 250 | 18 | ø250 | 237.6 | TR06.02.0012 | 0012 | Mechanické – tok - Doplňkový průtok: 0 m3/s; Průtok: 0 m3/s; Reynoldsovo číslo: 0; Rychlost: 0 m/s; Stav průtoku: Laminární; Fázování - Bouráno ve FÁZI 2: yes; Fáze demolice: Fáze 2; Identifikační data - Komentáře: RUŠENÍ STÁVAJÍCÍ KANALIZAČNÍ PŘÍPOJKY (ODBOČKA ZASLEPENA, POTRUBÍ ZAFOUKÁNO POPÍLKOBETONEM A KONCE ZASLEPENY) - ŘEŠENO V RÁMCI DBP
12779231 | 6977.56 | 0.04908 | 5.48016 | ø250 mm | 0.000526094 | -2542.21 | -2667.18 | -2806.7 | 2 | -2931.68 | Stávající stav |  | Nedefinovaný |  | -2925.48 | 250 | 20 | ø250 | 237.6 | TR06.02.0014 | 0014 | Mechanické – tok - Doplňkový průtok: 0 m3/s; Průtok: 0 m3/s; Reynoldsovo číslo: 0; Rychlost: 0 m/s; Stav průtoku: Laminární; Fázování - Bouráno ve FÁZI 2: yes; Fáze demolice: Fáze 2; Identifikační data - Komentáře: RUŠENÍ STÁVAJÍCÍ KANALIZAČNÍ PŘÍPOJKY (ODBOČKA ZASLEPENA, POTRUBÍ ZAFOUKÁNO POPÍLKOBETONEM A KONCE ZASLEPENY) - ŘEŠENO V RÁMCI DBP
12858378 | 40.3008 | 0.01227 | 0.0158261 | ø125 mm | 0.00105396 | -4417.54 | -4457.84 | -4417.54 |  | -4457.84 | Fáze 1 | SW_Deště přípojka | Sanitární | SW_Deště přípojka 3 | -4457.84 | 125 | 2 | ø125 | 118.6 | TR06.02.0025 | 0025 | SW_Deště přípojka 3 | Jiné - Páteřní trasa: yes
12864954 | 5445.29 | 0.0706752 | 5.13207 | ø300 mm | 0.000416667 | -4795.37 | -5054.23 | -4945.34 | 2 | -5204.2 | Stávající stav | SW_Splašky řad | Sanitární | SW_Splašky řad 1 | -5204.2 | 300 | 45 | ø300 | 300 | TR06.02.0027 | 0027 | SW_Splašky řad 1; SW_Deště přípojka 3
12864978 | 281.771 | 0.0706752 | 0.265563 | ø300 mm | 0.000416667 | -4910.67 | -5066.27 | -5060.64 | 1.99939 | -5216.24 | Stávající stav | SW_Splašky řad | Sanitární | SW_Splašky řad 1 | -5216.24 | 300 | 45 | ø300 | 300 | TR06.02.0028 | 0028 | SW_Splašky řad 1

# IfcValve: Šachta kanalizační kruhová:Šachta kanalizační kruhová S.1, Šachta kanalizační kruhová:Šachta kanalizační kruhová S.1:12777742
In: 1.NP_SO-101,102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Tloušťka dna: 200 mm; Tloušťka stěny: 120 mm; Vnější průměr_Dolní: 1200 mm; Vnější průměr_Horní: 625 mm; Výška přechodu: 600 mm; Výška šachty: 3300 mm; Výška vyrovnávací skruže: 250 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: SŠ; Kód sestavy: AT02; Komentáře k typům: STÁVAJÍCÍ KANALIZAČNÍ ŠACHTA; Název typu: Šachta kanalizační kruhová S.1; Označení typu: 02; Popis: Šachta; Popis sestavy: Betonová; URL: www.cadconsulting.cz; Version: 1.0
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Šachta kanalizační kruhová; o: 287.5 mm; rt: 480 mm; rth: 192.5 mm; vp: 600 mm; vph: 312.5 mm; vz: 2250 mm
Classification: AT02 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: G; CCI Komponenta: EBB; CCI Technický systém: JD
Vazby - Podlaží: 1.NP_SO-101,102; Přesunout s blízkými prvky: no; Výška od podlaží: -1520.63 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 1.37504 m3
Identifikační data - ID pozice: 01; Kód prvku: AT02.02.0002; Označení: 0002
Jiné - Páteřní trasa: yes; Rodina: Šachta kanalizační kruhová; Id typu: 12777959; Rodina a typ: Šachta kanalizační kruhová: Šachta kanalizační kruhová S.1; Typ: Šachta kanalizační kruhová S.1

# IfcValve: Šachta kanalizační kruhová:Šachta kanalizační kruhová S.2, Šachta kanalizační kruhová:Šachta kanalizační kruhová S.2:12765107
In: 1.NP_SO-101,102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Tloušťka dna: 200 mm; Tloušťka stěny: 120 mm; Vnější průměr_Dolní: 1200 mm; Vnější průměr_Horní: 625 mm; Výška přechodu: 600 mm; Výška šachty: 3400 mm; Výška vyrovnávací skruže: 250 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: SŠ; Kód sestavy: AT02; Komentáře k typům: kanalizační kruhová; Název typu: Šachta kanalizační kruhová S.2; Označení typu: 01; Popis: Šachta; Popis sestavy: Betonová; URL: www.cadconsulting.cz; Version: 1.0
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Šachta kanalizační kruhová; o: 287.5 mm; rt: 480 mm; rth: 192.5 mm; vp: 600 mm; vph: 312.5 mm; vz: 2350 mm
Classification: AT02 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: G; CCI Komponenta: EBB; CCI Technický systém: JD
Vazby - Podlaží: 1.NP_SO-101,102; Přesunout s blízkými prvky: no; Výška od podlaží: -2460.46 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 1.41575 m3
Identifikační data - ID pozice: 02; Kód prvku: AT02.01.0001; Označení: 0001
Jiné - Id typu: 12765091; Páteřní trasa: yes; Rodina: Šachta kanalizační kruhová; Rodina a typ: Šachta kanalizační kruhová: Šachta kanalizační kruhová S.2; Typ: Šachta kanalizační kruhová S.2

# IfcValve: Šachta kanalizační kruhová:Šachta kanalizační kruhová STÁVAJÍCÍ (7)
In: 1.NP_SO-101,102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Tloušťka dna: 200 mm; Tloušťka stěny: 120 mm; Vnější průměr_Dolní: 1200 mm; Vnější průměr_Horní: 625 mm; Výška přechodu: 600 mm; Výška šachty: 4000 mm; Výška vyrovnávací skruže: 250 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: SŠ; Kód sestavy: AT02; Komentáře k typům: STÁVAJÍCÍ KANALIZAČNÍ ŠACHTA; Název typu: Šachta kanalizační kruhová STÁVAJÍCÍ; Označení typu: 04; Popis: Šachta; Popis sestavy: Betonová; URL: www.cadconsulting.cz; Version: 1.0
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Šachta kanalizační kruhová; o: 287.5 mm; rt: 480 mm; rth: 192.5 mm; vp: 600 mm; vph: 312.5 mm; vz: 2950 mm
Classification: AT02 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: G; CCI Komponenta: EBB; CCI Technický systém: JD
Vazby - Podlaží: 1.NP_SO-101,102; Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Stávající stav
Kóty - Objem: 1.66006 m3
Identifikační data - ID pozice: 02; ID systému: 101
Jiné - Rodina: Šachta kanalizační kruhová; Id typu: 12780150; Rodina a typ: Šachta kanalizační kruhová: Šachta kanalizační kruhová STÁVAJÍCÍ; Typ: Šachta kanalizační kruhová STÁVAJÍCÍ
Name (Šachta kanalizační kruhová:Šachta kanalizační kruhová STÁVAJÍCÍ:...) | Výška od podlaží (mm) | Kód prvku | Označení
12779311 | -1520.63 | AT02.04.0004 | 0004
12779319 | -1520.63 | AT02.04.0005 | 0005
12779329 | -1240.63 | AT02.04.0006 | 0006
12779337 | -1235.63 | AT02.04.0007 | 0007
12779349 | -2560.63 | AT02.04.0008 | 0008 | Identifikační data - Komentáře: ZAPRAVENÍ NOVÉ PŘÍPOJKY DO STÁVAJÍCÍ ŠACHTY
12779414 | -2840.63 | AT02.04.0009 | 0009
12781343 | -2840.63 | AT02.04.0010 | 0010

# IfcWasteTerminal: Liniový žlab:Šířka 150 mm, Liniový žlab:Šířka 150 mm:12870493
In: -1.PP_SO-101
Type - PredefinedType: USERDEFINED; Material: PC, Stahl, verzinkt, UP-GF(grey)
Type - Celá legenda - B_cw: NW 150; B_Modelltext: MEA channel; grating depth: 20 mm
Type - Data - execution documents: according to drawing and description; Installation technology: einclusive foundation; Material foundation: concrete; Typ drainage: Typ M
Type - Vlastnosti modelu - clear width mm drainage system: 150; Construction drainage system: box channel, U-form; Part, drainage: Drainage channel
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Material channel: UP-GF(grey); Material Endcap: PC
Type - Kóty - channel body height: 75 mm; channel body width: 186 mm; clear width: 150 mm; Diameter outside outlet: 110 mm
Type - Identifikační data - Číslo OmniClass: 23.70.50.00; Hersteller und Typ - Ausschreibender gleichwertig: wie MEA Bautechnik GmbH, Modell MEARIN Plus F; Indexovaná poznámka: Drainage channel for surface water; Kód sestavy: BC04; Komentáře k typům: LINIOVÝ ODVODŇOVACÍ ŽLAB - OŽ3; Model: MEARIN Plus F; Nadpis OmniClass: Liquid Waste Handling Services; Název typu: Šířka 150 mm; Označení typu: 02; Popis sestavy: Liniové; URL: https://www.mea-group.com; Výrobce: MEA Bautechnik GmbH business unit MEA Water Management
Type - Jiné - Kategorie: Instalační zařizovací předměty; MEA- clear width: 150; Název rodiny: Liniový žlab
Classification: BC04 Uniformat (Uniformat); Group: SW_Deště přípojka 1
Celá legenda - B_Abd show G1: yes; B_Abd show G2: no; B_Abd show G3: no; B_Abd show G4: no; B_Abd show G5: no; B_channel body end: 0 mm; B_channel body start: 156 mm; B_cover group: 1; B_cover width: 172 mm; B_end revision element: 1 mm; B_Foundation length: 6400 mm; B_offset end: 0 mm; B_Revision left: 7 mm; B_Revision right: 7 mm; B_Revision shown: no; B_TopSlot height: 1 mm; B_TopSlot side: 8 mm; B_vertical offset: 0 mm; Foundation width: 150 mm; offset outlet: 150 mm
Data - MEA planing help: https://www.mea-group.com/de/en/services/
Vlastnosti modelu - Loading class drainage system: C 250; Product website: https://www.mea-group.com/de/en/products/drainage-channel-mearin-plus/; Slope type/percent drainage component: ohne Gefälle; suitable drainage component: not suitable for the diagonal or transvers travel of motorways and highway; technical product information: https://www.mea-group.com/de/en/services/technical-documentation/
Text - CCI Funkční systém: G; CCI Komponenta: WMB; CCI Technický systém: JD
Vazby - Délka: 6250 mm; Odsazení od hostitele: -875.142 mm; Pracovní rovina: Podlaží : 1.NP_SO-101,102
Fázování - Fáze vytvoření: Fáze 2
Mechanické - Typ systému: SW_Deště přípojka; Klasifikace systému: Sanitární; Název systému: SW_Deště přípojka 1
Stavba - Cover: slotted; Def Cover: 1; Def Loading class: 3; Endcap end: no; Endcap start: yes; Foundation view: no; Loading class: C 250; outlet: yes; Revision element beginning: yes; TopSlot left: no; TopSlot middle: no
Kóty - Jmenovitá velikost výstupu: 125 mm; Objem: 0.0460953 m3; Plocha: 12.2074 m2
Identifikační data - Kód prvku: BC04.02.0002; Označení: 0002
Jiné - Páteřní trasa: yes; Id typu: 12809355; MEA- channel length: 6400 mm; MEA- cover: slotted; MEA- edge: GFK; MEA- endcap: 1; MEA- loading class: C 250; MEA- revision TopSlot: 1; Rodina: Liniový žlab; Rodina a typ: Liniový žlab: Šířka 150 mm; Typ: Šířka 150 mm
